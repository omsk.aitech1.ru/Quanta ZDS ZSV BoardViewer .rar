# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDDQ_SRC:
  vias: v4(77.59,59.29) v4(77.85,55.03)
VDDQ_VIN:
  vias: v4(71.78,52.26)
VINLDO1:
  vias: v4(75.36,46.29) v4(76.83,45.96)
VINVR2:
  vias: v4(69.95,40.14)
VINVR3: length 2.3
  TOP w0.203: v2(69.72,43.98) 69.52,44.19 PU5.G9
  GND1 w0.203: v9(69.95,43.73) 69.72,43.96 v2(69.72,43.98)
  GND2 w0.203: v7(69.67,44.03) 69.95,43.76 v9(69.95,43.73)
  IN4 w0.203: v8(68.65,44.42) 69.03,44.03 v7(69.67,44.03)
VINVR5: length 10.2
  GND1 w0.203: v9(67,45.69) 67.46,45.23 v2(67.52,45.23)
  IN3 w0.254: v9(67,45.69) 66.67,46.02 64.06,46.02 v8(61.34,48.73)
  BOTTOM w0.117: PR90.2 61.1,48.73 60.88,48.95 60.88,50.53 v4(60.57,50.83)
VSSGT_SENSE: length 77
  IN2 w0.254: v3(124.02,46.13) 124.05,46.15 125.08,46.15 125.38,46.44 126.17,46.44 v9(126.43,46.71) 127.32,47.59 138.04,47.59 139.42,46.21 145.1,46.21 147.69,43.63 153.93,43.63 155.21,42.34 155.21,33.16 155.22,33.15 155.22,32.78 155.21,32.78 155.21,25.66 157.73,23.15 159.02,23.15 161.72,20.45 165.96,20.45 v4(166.74,21.24)
  GND2 w0.254: v9(126.43,46.71) v8(126.43,45.42)
  BOTTOM w0.203: v8(126.43,45.42) 126.26,45.25 PR118.2 ; PR287.1 174.06,16.87 173.68,16.49 172.42,16.49 172.03,16.1 170.9,16.1 166.74,20.25 v4(166.74,21.24)
VSSSA_SENSE: length 130.8
  GND1 w0.254: v9(116.02,46.98) 115.92,46.88 115.92,46.48 v2(115.99,46.41)
  IN3 w0.254: v9(116.02,46.98) 116.17,47.13 116.17,47.53 116.96,48.31 116.96,49.46 v8(116.63,49.79) 116.63,49.85 116.91,50.13 117.7,50.13 125.78,58.21 158.43,58.21 166.35,50.29 175.31,50.29 176.44,51.42 185.15,51.42 186.44,50.13 187.03,50.13 187.67,49.5 190.14,49.5 192.66,46.97 192.66,33.66 186.71,27.7 185.11,27.7 184.06,26.65 184.06,21.09 180.53,17.55 177.8,17.55 176.96,16.71 176.96,16.25 177.23,15.97 177.56,15.97 177.74,16.15 v4(177.74,16.34)
  BOTTOM w0.203: v4(177.74,16.34) 177.52,16.11 177.52,16.11 177.42,16.01 177.37,15.97 PR302.1
VSSSENSE: length 107
  GND1 w0.254: v2(117.28,46.9) v9(117.6,47.22)
  IN3 w0.254: v4(185.95,29.63) 186.31,29.27 187.37,29.27 191.91,33.81 191.91,45.84 188.9,48.85 187.41,48.85 186.77,49.49 185.97,49.49 185.81,49.65 166.08,49.65 158.17,57.57 126.08,57.57 119.94,51.43 119.94,50.64 119.48,50.17 118.72,50.17 v8(118.36,49.81) 118.36,49.66 117.72,49.03 117.72,47.35 v9(117.6,47.22)
  BOTTOM w0.203: v4(185.95,29.63) 185.47,29.63 185.21,29.37 185.21,29.1 184.94,28.84 PR191.1
13_CCD_PW:
  vias: v4(4.54,17.33)
8350_GND: length 19.5
  IN3 w0.508: 162.12,12.73 162.12,12.4 163.01,11.51 v8(163.01,8.77)
  BOTTOM w0.254: U20.A2 154.3,5.02 154.79,5.02 154.83,5.06
  BOTTOM w0.279: R487.2 163.8,13.58 L15.1
  BOTTOM w0.508: L15.1 163.6,13.38 C454.2 ; v8(163.01,8.77) 163.14,8.64 163.14,7.13 159.38,3.37 C453.2 157.2,3.37 155.51,5.06 154.83,5.06
  vias: v7(162.58,13.47) v7(162.78,13.29) v8(162.58,13.47) v8(162.78,13.29) v10(162.58,13.47) v10(162.78,13.29)
36001_CC1: length 8.8
  IN4 w0.071: v8(233.79,21.06) 233.32,21.54 233.32,24.52 v8(233.8,25)
  BOTTOM w0.117: v8(233.79,21.06) R309.1 232.67,21.56 232.53,21.7 231.01,21.7 v4(230.88,21.57) ; U14.12 v8(233.8,25)
36001_CC2: length 6.2
  IN4 w0.071: v8(234.18,20.56) 234.18,21.06 233.55,21.7 v8(233.55,22.51)
  BOTTOM w0.117: U14.6 233.8,23.1 233.55,22.84 v8(233.55,22.51) 233.12,22.51 v4(232.91,22.71) ; R365.1 R364.2 233.79,20.17 v8(234.18,20.56)
+1.8U: length 134.1
  TOP w0.203: v4(183,10.56) 182.41,11.16 v4(178.71,11.16)
  IN1 w0.203: v1(60.47,42.86) 59.25,42.86 58.34,41.94 57.68,41.94 57.37,41.64 54.48,41.64 54.1,41.26 50.03,41.26 49.78,41 49.78,37.32 51.28,35.82 53.99,35.82 54.78,35.03 55.5,35.03 57.62,32.92 65.06,32.92 v3(65.83,33.69)
  IN1 w0.254: v13(148.96,32.06) 149.73,32.06 v13(149.75,32.09)
  IN1 w0.381: v13(111.79,15.76) 111.8,15.77 v13(111.8,16.57) 111.78,16.59 v13(111.78,17.36)
  IN2 w0.203: v3(65.83,33.69) 66.8,34.66 71.74,34.66 73.6,32.8 77.36,32.8 77.97,33.41 79.65,33.41 80.47,34.23 81.24,34.23 81.6,34.6 83.53,34.6 84.47,35.54 84.47,36.72 85.24,37.49 85.24,39.28 88.15,42.2 91.18,42.2 93.16,44.18 v4(93.16,44.69)
  IN3 w0.203: v4(229.86,22.08) 227.37,19.59 212.9,19.59 211.45,18.14 210.31,18.14 205.1,12.94 197.86,12.94 197.18,12.25 195,12.25 194.25,11.5 185.8,11.5 185.45,11.15 183.59,11.15 v4(183,10.56)
  BOTTOM w0.203: U5A1.U10 118.84,20.88 v13(119.24,20.48) ; R307.1 v4(229.86,22.08) ; v13(100.73,20.54) 101.07,20.89 U4A1.U10 ; U7A1.A5 148.61,42.16 ; U7A1.U5 148.67,31.76 ; U6A1.U10 144.57,14.43 v13(144.21,14.08) ; U4A1.A10 111.83,21.25 v13(111.85,21.25) ; U5A1.A10 129.6,21.25 v13(129.62,21.25) ; U7A1.A6 147.81,42.16
  vias: v4(87.29,58.44) v4(87.8,59.29) v4(87.95,58.44) v4(88.64,58.22) v4(90.9,24.9) v4(91.54,24.87) v4(92.17,24.87) v4(92.53,44.87) v4(93.44,45.27) v4(97.91,16.97) v4(114.52,15.86) v4(129.59,17.34) v4(129.59,16.54) v4(129.61,15.76) v4(131.44,16.32) v4(131.44,15.36) v4(131.46,17.18) v4(148.18,14.05) v4(148.84,11.95) v4(149.02,14.03) v4(149.47,11.95) v4(149.83,14.03) v4(150.11,11.95) v4(151.73,28.53) v4(153.49,15.5) v4(153.51,14.82) v4(153.84,16.14) v4(178.05,11.16) v7(112.82,13.14) v7(113.25,13.14) v7(113.71,13.11) v7(114.12,13.11) v7(114.55,13.14) v7(115.08,13.16) v7(115.54,13.16) v7(115.97,13.16) v7(116.43,13.16) v7(144.6,42.16) v7(144.6,31.76) v7(144.6,24.83) v8(112.82,13.14) v8(113.25,13.14) v8(113.71,13.11) v8(114.12,13.11) v8(114.55,13.14) v8(115.08,13.16) v8(115.54,13.16) v8(115.97,13.16) v8(116.43,13.16) v8(144.6,42.16) v8(144.6,31.76) v8(144.6,24.83) v10(112.82,13.14) v10(113.25,13.14) v10(113.71,13.11) v10(114.12,13.11) v10(114.55,13.14) v10(115.08,13.16) v10(115.54,13.16) v10(115.97,13.16) v10(116.43,13.16) v10(144.6,42.16) v10(144.6,31.76) v10(144.6,24.83) v13(100.75,17.35) v13(100.75,16.56) v13(100.75,15.75) v13(100.75,14.96) v13(118.46,17.31) v13(148.13,42.48) v13(148.93,42.48) v13(149.73,42.5) v13(153.13,28.58) v13(153.54,29.01) v13(153.92,29.5)
+1.8U_S2:
  vias: v4(84.75,58.35)
+AZA_VDD: length 25.7
  IN3 w0.305: v8(239.77,13.82) 239.86,13.92 v4(243.49,13.92) 243.49,13.54 244.34,12.68 244.98,12.68 246.63,11.03 246.63,6.34 245.51,5.22 v4(244.85,5.22)
  BOTTOM w0.203: 245.44,4.57 245.75,4.88 U19.36 ; v4(244.93,12.63) 245.34,12.22 245.58,12.22 245.75,12.04 U19.1 ; R432.1 237.74,13.7
  BOTTOM w0.305: v8(239.77,13.82) 237.86,13.82 237.74,13.7 ; v4(244.85,5.22) C460.1 245.44,4.57 ; v4(243.49,13.92) 243.13,14.27 R381.1 242.69,13.68 243.26,13.11 C375.1 243.41,13.1 243.77,12.74 C380.1 244.82,12.74 v4(244.93,12.63)
+BAT_DIS: length 25.2
  IN4 w0.508: v4(70.17,26.79) 70.87,26.09 79.98,26.09 82.39,23.68 82.39,19.92 v5(81.6,19.13)
  BOTTOM w0.508: PR212.2 65.48,27.02 65.49,27.03 v4(65.49,28.13) 65.59,28.23 v4(68.76,28.23) 69.34,28.23 70.17,27.4 v4(70.17,26.79)
  vias: v4(79.9,18.27)
+BATCHG:
  vias: v4(83.71,15.53) v4(85.19,18.62)
+MUX_PWR: length 18.9
  IN3 w0.508: 239.13,22.21 240.4,20.94 v4(240.4,20.68) ; 239.13,22.21 239.01,22.33 237.61,22.33 v4(237.1,22.84) ; 239.13,22.21 v4(239.13,26.78)
  BOTTOM w0.305: C314.2 237.48,24.61 237.58,24.51 238.01,24.51 238.11,24.62 U15.6 ; C341.2 239.89,27.54 240.03,27.4 U15.10
  BOTTOM w0.508: v4(239.13,26.78) 239.07,26.84 239.07,28.09 239.01,28.15 ; C314.2 237.13,22.87 v4(237.1,22.84) 236.59,22.33 R372.1 ; 239.01,28.15 R311.2 ; 239.01,28.15 239.79,28.15 C341.2
  vias: v4(240.79,19.79)
+POA_PWR: length 3.6
  BOTTOM w0.381: Q6062.1 173.98,10.9 173.02,11.87 173.02,12.17 172.32,12.88 C726.2
  vias: v4(171.44,14.46)
+PRWSRC: length 22.7
  IN4 w0.508: v4(67.23,17.52) 67.98,18.26 84.41,18.26 86.68,20.54 86.68,21.61 86.46,21.84 v5(86.46,21.85)
  BOTTOM w0.203: PR278.2 67.13,17.62 v4(67.23,17.52)
  vias: v4(88.28,21.98) v4(88.36,19.13)
+SMDDR_VREF_CA: length 98.8
  TOP w0.457: v13(148.94,37.94) 148.94,37.72 149.4,37.27 151.48,37.27
  TOP w0.508: 151.48,37.27 151.53,37.32 152.98,37.32 154.12,36.18 154.12,33.62 v4(154.77,32.97) 154.77,32.33 154.76,32.32 154.76,27.72 155.04,27.43 155.04,22.16 v4(154.76,21.88) 154.76,20.43 v4(153.87,19.54) 154.76,18.65 v4(154.76,16.4) 154.76,15.04 153.16,13.44 143.54,13.44 143.11,13.01 133.27,13.01 132.51,13.77 129.76,13.77 128.54,12.55 v4(125.62,12.55) 124.89,11.82 v4(112.9,11.82) 107.33,11.82 v4(107.24,11.9) v13(107.24,15.76)
  IN2 w0.508: v13(125.01,15.76) 125.01,13.16 v4(125.62,12.55)
  IN4 w0.508: v13(148.94,20.61) 149.58,19.97 153.44,19.97 v4(153.87,19.54)
  BOTTOM w0.203: v13(125.01,15.76) 124.69,16.08 U5A1.H4 ; v13(148.94,37.94) 149.27,37.61 U7A1.H4 ; U6A1.H4 149.27,20.28 v13(148.94,20.61) ; U4A1.H4 106.92,16.08 v13(107.24,15.76)
  BOTTOM w0.508: v4(125.62,12.55) 125.22,12.15 C6A9.1 C6L7.1 ; C6A4.1 v4(154.77,32.97) ; v4(107.24,11.9) 107.24,11.27 107.56,10.95 C6L8.1
  vias: v4(154.93,22.84)
+SMDDR_VREF_DQA: length 17.1
  IN3 w0.508: 140.18,20.35 140.18,36.46
  BOTTOM w0.203: U6A1.J11 143.76,19.63 v13(143.43,19.31) ; v13(143.39,36.71) 143.63,36.96 U7A1.J11
  vias: v4(139.21,20.28) v7(139.74,20.05) v7(139.74,19.69) v7(140.02,38.31) v7(140.02,38.01) v7(140.02,37.65) v8(139.74,20.05) v8(139.74,19.69) v8(140.02,38.31) v8(140.02,38.01) v8(140.02,37.65) v10(139.74,20.05) v10(139.74,19.69) v10(140.02,38.31) v10(140.02,38.01) v10(140.02,37.65)
+SMDDR_VREF_DQB: length 23.5
  IN3 w0.508: v13(124.34,22.08) 124.09,22.33 124.08,22.33 123.67,22.75 123.67,23.38 123.92,23.63 v4(123.92,24.26) 107.36,24.26 107.23,24.14 v4(106.6,24.14) 106.15,23.69 106.15,23.17 106.67,22.65 v13(106.67,22.09)
  BOTTOM w0.254: v13(106.67,22.09) U4A1.J11 ; U5A1.J11 124.04,21.78 v13(124.34,22.08)
  vias: v4(121.86,26.27)
+SMDDR_VTERM: length 130
  TOP w0.508: PR41.1 76.82,43.8 v4(77.21,44.19)
  IN3 w0.508: 137.03,37.88 137.03,33.99 128.34,25.31 122.93,25.31 122.22,26.02 120.72,26.02
  IN4 w0.508: 118.79,26.12 106.95,26.12 106.27,26.8 101.36,26.8 101.15,27.01 99.72,27.01 98.91,26.2 98.91,25.98 96.84,23.91 90.24,23.91 89.29,24.86 89.29,25.47 83.76,31 83.76,35.08 82.54,36.3 82.54,38.11 81.83,38.82 79.7,38.82 79.29,38.41 77.03,38.41 76.36,39.09 76.36,43.02 76.91,43.58 76.91,43.9 v4(77.21,44.19) ; 120.72,26.07 120.82,26.07 120.95,25.94 123.92,25.94 124.12,25.74 145.03,25.74 145.88,24.89 153.7,24.89 154.39,24.2 154.39,22.55 154.07,22.23 154.07,21.52 155.57,20.02 v4(156.71,20.02)
  BOTTOM w0.508: v4(156.71,20.02) 156.71,20.86 156.48,21.1 R313.2 ; v4(77.21,44.19) 76.79,44.61 v4(76.79,45.24) PC95.2 PC238.2
  vias: v7(119.5,26.14) v7(119.91,26.14) v7(137.36,38.41) v7(137.64,38.46) v8(119.5,26.14) v8(119.91,26.14) v8(137.36,38.41) v8(137.64,38.46) v10(119.5,26.14) v10(119.91,26.14) v10(137.36,38.41) v10(137.64,38.46)
+USB_RE_PWR_C: length 7.8
  BOTTOM w0.203: R364.1 R308.1 R307.2 235.07,22.08 v4(236.09,23.1) 236.7,23.71 236.7,24.26 236.35,24.61 C329.2 235.95,24.87 U14.3
+VA:
  vias: v4(95.68,5.72) v4(96.01,15.98) v4(96.31,13.67) v5(96.59,6.37) v5(96.92,5.7) v5(97.33,6.37) v5(97.68,5.7) v5(98.06,6.37) v5(203.96,4.55) v5(204.34,3.92) v5(204.84,4.55) v5(205.23,3.92) v5(205.61,4.55) v5(209.92,19.79) v5(210.69,19.79) v5(210.69,19.03) v5(211.45,19.79) v5(211.45,19.03)
+VAD: length 21.4
  IN2 w0.508: v5(90.04,18.74) 89.83,18.94 87.27,18.94 85.82,17.49 73.07,17.49 72.66,17.89 71.67,17.89 70.86,17.08 v5(70.86,16.02)
  vias: v4(91.99,23.15) v4(93.72,21.93)
+WL_VDD: length 6.4
  TOP w0.203: R91.1 198.75,39.44 v4(198.34,39.84)
  BOTTOM w0.203: R202.1 198.47,37.23 197.58,38.12 196.93,38.12 v4(196.91,38.13)
  BOTTOM w0.508: Q12.2 199.3,41.01 198.34,40.06 v4(198.34,39.84) ; R198.2 v4(196.91,38.13) ; Q13.2 v4(194.43,39.72)
  vias: v4(39.87,57.26) v4(39.87,56.62) v4(40.63,57.26) v4(40.63,56.62) v4(67.81,59.42) v4(67.81,58.78) v4(68.45,59.42) v4(68.45,58.78) v4(96.82,56.62) v4(97.45,56.62) v4(97.78,57.18) v4(98.42,57.18) v4(122.42,56.88) v4(161.16,57.51) v4(194.46,37.12) v4(194.46,36.46) v4(194.46,35.8) v4(197.68,33.9) v4(197.68,33.21) v4(200.65,52.84) v4(201.29,52.62) v4(201.29,51.98)
A_LAD0_R: length 3.9
  TOP w0.117: CN1.64 201.08,35.85 200.91,36.02 200.91,36.89 v4(200.27,37.52) 199.98,37.23 R106.1
A_LAD1_R: length 3
  TOP w0.117: R111.1 200.04,36.46 v4(200.27,36.23) 200.65,35.85 201.15,35.35 CN1.66
A_LAD2_R: length 4.8
  TOP w0.117: CN1.68 200.74,34.85 199.88,35.7 R116.1 199.3,35.46 199.13,35.29 198.09,35.29 v4(197.86,35.06)
A_LAD3_R: length 2.8
  TOP w0.117: R120.1 199.56,34.94 199.87,34.63 v4(199.9,34.63) 200.59,34.63 200.86,34.35 CN1.70
AC_PRESENT: length 81.4
  TOP w0.117: R99.2 102.94,38.03 102.74,37.83 v3(102.74,37.68)
  IN2 w0.064: v3(111.48,36.8) 111.36,36.68 110.02,36.68 109.9,36.56 108.91,36.56 108.25,35.9 107.49,35.9
  IN2 w0.066: v3(102.74,37.68) 102.62,37.79 102.37,37.79 101.9,38.26 99.76,38.26 99.41,37.91 99.13,37.91
  IN2 w0.074: 107.49,35.9 107.31,36.08 105.93,36.08 105,37.02 104.58,37.02 104.27,37.33 103.16,37.33 102.81,37.68 v3(102.74,37.68)
  IN2 w0.094: v4(48.36,14.16) 52.91,14.16 56.25,17.51 56.25,22.71 61.7,28.16 66.09,28.16 66.26,27.99 75.88,27.99 77.29,26.59 86.51,26.59 90.89,30.98 92.46,30.98 96.94,35.46 96.94,36.22 98,37.28 98.43,37.28 99.05,37.91 99.13,37.91
  BOTTOM w0.117: U17.B12 49.36,13.41 49.11,13.66 48.75,13.66 48.36,14.06 v4(48.36,14.16)
ACC_INT_BASE: length 116.8
  TOP w0.117: R123.2 80.75,34.16 80.38,33.79 v4(80.38,33.13) 80.38,32.7 80.87,32.21 82.56,32.21 83.85,30.93 90.27,30.93 90.74,30.45 92.79,30.45 93.81,29.43 v1(93.81,29.2)
  IN1 w0.071: v2(153.92,6.64) 151,6.64 149.9,5.54 133.37,5.54 132.95,5.97 122.08,5.97 121.82,6.23 105.78,6.23 103.93,8.08 99.9,8.08 99.11,8.86 98.73,8.86 95.31,12.29 95.31,17.67 94.67,18.31 94.67,22.58 92.73,24.52 92.73,28.12 v1(93.81,29.2)
  GND1 w0.127: v9(153.92,6.29) v2(153.92,6.64)
  IN3 w0.094: v8(161.16,7.47) 161.45,7.77 164.27,7.77 165.31,8.81 165.31,11.72 165.46,11.87 165.46,13.02 165.05,13.44 v8(165.05,14.12)
  GND2 w0.127: v9(153.92,6.29) v8(153.56,6.29)
  BOTTOM w0.117: v8(161.16,7.47) 160.9,7.22 160.47,7.22 160.22,6.97 158.68,6.97 158.58,7.07 154.71,7.07 154.18,6.54 153.82,6.54 v8(153.56,6.29) ; R430.2 164.91,14.46 165.05,14.33 v8(165.05,14.12)
ACC_INT_BASE_R: length 141
  TOP w0.117: U5.11 81.66,34.79 81.48,34.61 R123.1 80.56,34.61 80.38,34.78 80.38,35.41 v1(80.21,35.58) 79.94,35.58 79.52,35.16 v4(79.52,34.55)
  IN1 w0.071: v4(177.1,54.05) 175.69,52.65 167.27,52.65 159.99,59.93 107.64,59.93 105.94,58.22 101.54,58.22 100.93,57.61 97.12,57.61 96.34,56.83 96.34,55.53 92.52,51.72 92.52,47.44 90.96,45.88 90.96,44.52 90.73,44.29 88.79,44.29 88.03,44.29 84.47,40.72 84.12,40.72 83.71,40.32 83.51,40.32 83.19,40 83.19,39.44 81.32,37.57 81.32,36.76 80.21,35.65 v1(80.21,35.58)
  IN4 w0.071: v4(177.1,54.05) 177.65,53.5 182.85,53.5 188.08,48.27 v8(192.73,48.27)
  BOTTOM w0.117: v8(192.73,48.27) R174.1 193.03,49.02 193.29,48.76 193.59,48.76 193.68,48.84 Q11.1
ACC_INT_PANEL: length 22.5
  IN3 w0.094: v8(160.98,6.79) 161.06,6.71 161.72,6.71 162.12,7.12 164.66,7.12 165.95,8.41 165.95,10.98 166.86,11.89 166.86,13.89 v8(167.13,14.16)
  BOTTOM w0.117: v4(168.98,15.5) 168.45,14.97 168.14,14.97 167.66,14.49 R436.2 v8(167.13,14.16) R445.2 ; U20.B4 153.82,6.04 154.19,6.04 154.86,6.71 158.43,6.71 158.53,6.61 160.8,6.61 v8(160.98,6.79)
ACC_INT_PANEL_R: length 238.7
  IN1 w0.071: v4(175.51,9.1) 175.52,9.11 184.14,9.11 188.39,13.37 188.82,13.37 190.23,14.78 190.23,16.54 190.67,16.98 190.67,23.63 189.12,25.17 189.12,27.5 190.16,28.54 190.16,31.62 191.54,33 193.29,33 193.84,32.45 195.38,32.45 196.49,33.56 196.49,42 195.55,42.94 195.55,46.01 v4(195.95,46.41)
  IN2 w0.094: v4(23.55,14.71) 23.55,13.99 31.97,5.57 50.87,5.57 51.43,6.13 52.42,6.13 53.77,4.78 60.42,4.78 63.8,8.16 64.56,8.16 67.63,11.23 73.95,11.23 74.67,11.95 76.04,11.95 76.8,11.18 95.02,11.18 99.86,6.34 131.25,6.34 132.62,4.98 138.5,4.98 139.79,3.69 160.5,3.69 165.92,9.11 170.21,9.11 170.38,9.28 175.33,9.28 v4(175.51,9.1)
  IN3 w0.094: v4(175.51,9.1) 174.95,9.66 v8(169.97,9.66)
  BOTTOM w0.117: Q11.4 194.98,48.33 195.08,48.43 R178.1 R186.1 196.23,47.74 196.39,47.58 196.39,46.84 v4(195.95,46.41) ; R436.1 v4(168.88,14.16) 168.95,14.16 169.18,13.93 169.18,13.3 169.69,12.78 169.76,12.78 169.92,12.63 169.92,9.71 v8(169.97,9.66) ; CN9.16 v4(23.55,14.71)
ACIN: length 238.9
  IN1 w0.071: v4(191.41,3.59) 191.46,3.64 191.46,4.88 191.76,5.19 195.07,5.19 198.09,8.21 199.42,8.21 201.03,9.83 201.03,12.3 201.34,12.61 v4(201.34,13.54)
  GND1 w0.06: v9(71.3,42.95) v2(71.02,43.23)
  IN3 w0.094: v4(64.84,17.39) 64.21,17.39 61.7,19.9 60.34,19.9 58.26,21.98 v7(58.26,23.05)
  GND2 w0.127: v9(71.3,42.95) 71.3,42.91 71.57,42.64 v7(71.57,42.61)
  IN4 w0.071: v8(48.22,12.02) 49.24,13.05 51.42,13.05 51.74,12.73 53.4,12.73 53.8,12.34 55.03,12.34 55.86,13.17 55.86,15.72 56.09,15.95 56.09,20.75 58.26,22.92 v7(58.26,23.05) 58.26,23.43 63.13,28.3 63.67,28.3 64.69,29.32 65.4,29.32 68.14,32.06 68.14,32.73 68.88,33.47 68.88,38.11 70.51,39.74 70.51,42 70.69,42.18 71.14,42.18 v7(71.57,42.61) ; v4(64.84,17.39) 64.84,17.21 65.45,16.59 66.82,16.59 67.07,16.85 68.67,16.85 69.43,17.61 73.1,17.61 73.45,17.26 94.33,17.26 100.23,11.35 104.67,11.35 105.1,10.93 134.39,10.93 136.08,12.62 152.76,12.62 152.97,12.41 154.46,12.41 154.82,12.77 162.16,12.77 162.71,12.22 162.81,12.22 163.51,11.53 169.33,11.53 171.18,9.67 172.52,9.67 173.09,10.24 178.96,10.24 180.84,8.36 184.14,8.36 184.91,9.13 184.91,9.51 185.54,10.14 185.54,11.67 187.04,13.16 195.98,13.16 196.97,12.17 200.53,12.17 201.34,12.99 v4(201.34,13.54)
  BOTTOM w0.117: Q6068.2 205.23,14.97 203.8,13.54 R10964.1 202.69,13.54 202.46,13.32 201.56,13.32 v4(201.34,13.54) ; U17.F12 49.14,11.66 48.58,11.66 v8(48.22,12.02) ; Q6069.2 186.68,4.3 187.57,5.19 R10999.1 187.86,4.48 188.59,3.74 191.26,3.74 v4(191.41,3.59)
  BOTTOM w0.178: 65.52,18.55 65.52,18.9 66.03,19.4 PU14.5
  BOTTOM w0.203: v4(64.84,17.39) 64.96,17.51 PR288.1 65.52,17.51 65.91,17.9 65.91,18.27 65.63,18.55 PR276.1
ACZ_RST#_AUDIO: length 183.4
  IN2 w0.094: v9(98.04,25.94) 96.22,24.12 96.22,21.66 95.36,20.8 95.36,16.42 103.21,8.57 128.01,8.57 128.26,8.82 133.93,8.82 134.27,8.48 144.98,8.48 145.47,8.97 146.87,8.97 147.37,8.48 152.36,8.48 154.01,10.14 161,10.14 163.29,12.43 170.35,12.43 171.1,13.17 182.91,13.17 183.64,12.45 185.11,12.45 185.77,13.11 189.02,13.11 189.86,13.95 197.04,13.95 197.98,13.01 211.08,13.01 211.56,13.49 216.27,13.49 216.64,13.85 217.84,13.85 218.3,13.39 221.18,13.39 222.26,14.47 228.48,14.47 v4(229.33,13.62) 229.84,13.62 230.66,14.44 248.33,14.44 v4(249.93,12.84)
  GND2 w0.117: v9(98.04,25.94) 98.24,25.94 v8(98.46,26.16)
  BOTTOM w0.117: R245.1 102.46,27.38 101.86,26.78 v4(101.49,26.78) 100.68,26.78 100.06,26.16 v8(98.46,26.16) ; v4(249.93,12.84) 249.93,12.39 249.75,12.2 U19.11 ; v4(229.33,13.62) 229.23,13.52 Q34.1
ACZ_SDIN: length 5.6
  BOTTOM w0.117: R377.1 246.9,15.45 247.16,15.2 247.16,14.97 247.31,14.82 248.38,14.82 248.76,14.43 248.76,13.39 248.69,13.31 248.69,12.39 248.55,12.25 U19.8
ACZ_SDIN0: length 187.9
  IN1 w0.06: 110.18,33.37 110.18,33.38 111.41,34.61 111.6,34.61 111.73,34.74 111.73,35 v11(111.8,35.07)
  IN1 w0.071: 110.18,33.37 110.12,33.31 108.46,33.31 108.18,33.03 106.39,33.03 103.26,29.89 103.26,29.69 102.51,28.94 102.46,28.94 102.06,28.53 101.46,28.53 100.09,27.16 v3(99,27.16)
  IN2 w0.094: v3(99,27.16) 98.9,27.05 98.9,26.45 98.51,26.06 98.51,25.74 96.62,23.85 96.62,15.73 103.37,8.97 126.48,8.97 126.79,9.28 134.94,9.28 135.34,8.88 144.82,8.88 145.42,9.48 146.93,9.48 147.53,8.88 152.12,8.88 153.78,10.54 160.83,10.54 163.21,12.91 170.05,12.91 170.89,13.75 180.99,13.75 181.17,13.57 183.27,13.57 183.99,12.85 184.95,12.85 185.61,13.51 188.85,13.51 189.9,14.55 200.94,14.55 202.09,13.41 210.91,13.41 211.39,13.88 216.02,13.88 216.38,14.25 218,14.25 218.46,13.79 221.01,13.79 222.5,15.28 227.78,15.28 227.96,15.09 228.48,15.09 229.23,14.34 230,14.34 230.5,14.84 245.46,14.84 v4(245.69,15.07)
  BOTTOM w0.117: R377.2 246.45,15.62 246.22,15.39 246.01,15.39 v4(245.69,15.07)
ACZ_SDOUT_AUDIO: length 179.3
  IN2 w0.094: v9(97.25,27.21) 96.98,26.94 96.98,26.87 96.66,26.55 96.66,26.25 95.02,24.62 95.02,22.15 94.05,21.18 94.05,13.49 100.41,7.13 103.81,7.13 104.18,6.76 133.96,6.76 134.43,6.29 138.89,6.29 139.88,7.28 145.49,7.28 145.85,7.65 146.5,7.65 146.87,7.28 152.94,7.28 154.6,8.94 161.49,8.94 163.71,11.16 170.94,11.16 171.63,11.85 178.72,11.85 179.32,11.25 189.63,11.25 190.57,12.19 196.25,12.19 197.64,10.79 201.63,10.79 202.65,11.81 211.58,11.81 212.05,12.29 217.66,12.29 217.76,12.19 221.67,12.19 222.76,13.28 227.98,13.28 228.93,12.33 230.25,12.33 231.16,13.25 238.71,13.25 239.33,12.63 245.04,12.63 245.51,13.1 246.07,13.1 247.09,13.1 247.35,12.83 v4(247.35,12.56)
  GND2 w0.117: v8(97.28,26.78) 97.28,27.19 v9(97.25,27.21)
  BOTTOM w0.117: v4(247.35,12.56) U19.5
ACZ_SPK: length 204
  TOP w0.117: R83.2 v4(104.03,39.69) 104.03,39.66 103.83,39.45 v3(103.83,38.95)
  IN1 w0.06: 107.75,38.35 107.98,38.12 108.38,38.12 108.6,38.33 v1(108.78,38.33)
  IN1 w0.071: v3(94.91,37.29) 94.72,37.1 94.72,35.23 94.91,35.03 94.91,31.53 94.05,30.66 94.05,28.88 93.11,27.94 93.11,24.67 95.05,22.73 95.05,18.47 95.69,17.83 95.69,12.44 98.89,9.24 99.27,9.24 100.05,8.46 104.09,8.46 105.94,6.61 121.97,6.61 122.24,6.34 133.21,6.34 v3(133.65,5.9) ; 107.75,38.35 107.26,38.83 106.14,38.83 105.93,38.62 104.49,38.62 104.15,38.95 v3(103.83,38.95)
  IN2 w0.074: v3(103.83,38.95) 103.53,38.65 102.79,38.65 102.26,39.17 100.72,39.17
  IN2 w0.094: v4(236.24,12.75) 231.23,12.75 230.41,11.94 228.21,11.94 227.34,12.81 226.12,12.81 225.61,12.3 222.35,12.3 221.84,11.79 217.6,11.79 217.5,11.89 213.83,11.89 213.35,11.41 202.81,11.41 201.8,10.4 197.48,10.4 196.08,11.79 190.73,11.79 189.79,10.85 185.11,10.85 182.87,8.62 181.35,8.62 179.7,10.27 176.32,10.27 175.72,9.67 170.21,9.67 170.05,9.51 165.75,9.51 160.33,4.09 139.96,4.09 138.67,5.37 134.17,5.37 v3(133.65,5.9) ; v3(94.91,37.29) 95.19,37.29 97.2,39.31 100.58,39.31 100.72,39.17
  BOTTOM w0.117: D20.2 240.96,14.19 241.41,13.75 241.41,12.43 241.13,12.15 236.84,12.15 v4(236.24,12.75)
ACZ_SYNC_AUDIO: length 181.5
  IN2 w0.094: v9(98.32,27.06) 97.45,26.19 97.45,25.92 95.82,24.28 95.82,21.82 94.97,20.97 94.97,14.52 101.56,7.93 104.14,7.93 104.51,7.55 137.08,7.55 137.61,8.08 145.15,8.08 145.63,8.57 146.71,8.57 147.2,8.08 152.54,8.08 154.2,9.74 161.16,9.74 163.45,12.02 170.66,12.02 171.39,12.76 182.76,12.76 183.47,12.05 185.28,12.05 185.94,12.71 189.96,12.71 190.23,12.99 196.58,12.99 196.96,12.61 211.25,12.61 211.72,13.09 216.45,13.09 216.81,13.45 217.67,13.45 218.13,12.99 221.34,12.99 222.43,14.08 228.31,14.08 229.25,13.14 229.93,13.14 230.83,14.04 240.4,14.04 241.02,13.42 244.68,13.42 245.15,13.89 247.99,13.89 v4(249.4,12.49)
  GND2 w0.117: v9(98.32,27.06) 98.9,27.06 v8(98.98,26.98)
  BOTTOM w0.117: U19.10 249.35,12.44 v4(249.4,12.49) ; R242.1 100.91,27.5 100.76,27.35 v4(99.33,27.35) 99.33,27.34 v8(98.98,26.98)
ADC0: length 20.8
  IN3 w0.094: v8(167.13,14.99) 166.17,14.04 165.61,14.04 165.44,13.87 165.44,13.27 165.62,13.09 165.62,11.8 165.47,11.65 165.47,8.61 164.47,7.61 161.67,7.61 161.16,7.09 160.78,7.09 v8(160.65,6.97)
  BOTTOM w0.117: U20.A5 154.18,6.29 154.78,6.89 158.5,6.89 158.6,6.79 160.47,6.79 v8(160.65,6.97) ; R435.2 167.1,15.63 T62.1
ADC3: length 20.2
  IN3 w0.094: v8(162.22,6.87) 164.63,6.87 166.11,8.34 166.11,10.85 167.1,11.84 v8(167.1,13.32)
  BOTTOM w0.117: v8(162.22,6.87) 162.12,6.97 162.12,7.27 161.92,7.47 161.67,7.47 161.28,7.08 161.28,6.59 161.12,6.43 158.45,6.43 158.35,6.53 154.95,6.53 154.21,5.79 U20.A4 ; T63.1 167.27,13.49 v8(167.1,13.32)
ADC4: length 19.7
  IN3 w0.094: v8(161.56,6.97) 161.56,7.27 161.74,7.45 164.54,7.45 165.63,8.54 165.63,11.58 165.78,11.73 165.78,13.15 165.68,13.26 v8(165.68,13.77)
  BOTTOM w0.117: v8(165.68,13.77) 165.5,13.6 R452.2 ; U20.B3 153.82,5.54 154.41,5.54 154.95,6.08 T64.1 156.64,6.08 156.9,6.35 158.28,6.35 158.38,6.25 161.2,6.25 161.56,6.61 v8(161.56,6.97)
ADC5: length 19.3
  IN3 w0.094: v8(166.06,12.05) 166.06,11.31 165.79,11.05 165.79,8.48 164.6,7.28 161.93,7.28 v8(161.84,7.2)
  BOTTOM w0.117: U20.A3 154.48,5.29 154.96,5.77 155.67,5.77 T65.1 156.56,4.76 157.06,4.25 159.49,4.25 161.84,6.61 v8(161.84,7.2) ; R457.2 165.5,12.25 165.63,12.12 165.98,12.12 v8(166.06,12.05)
ADOGND: length 23.1
  BOTTOM w0.203: C440.2 242.06,7.15 v4(241.85,6.94) ; C461.2 251.69,3.88 v4(251.53,3.72) ; U19.38 244.23,6.67 243.85,6.3 243.85,5.6 v4(243.71,5.45) ; U19.25 250.15,4.98 250.29,4.83 250.58,4.83 v4(250.83,5.08) ; C472.2 248.28,2.65 v4(248.1,2.47) 247.7,2.47 v4(247.49,2.68)
  BOTTOM w0.381: C434.2 v4(253.23,6.8)
  BOTTOM w0.508: v4(259.17,3.48) C471.2 260.44,3.48 260.52,3.56 D38.2 ; D34.2 v4(260.9,6.47) D31.2 ; v4(259.18,5.65) 259.87,5.65 C452.2 ; v4(242.01,2.78) 242.5,3.27 C468.1 ; v4(242.56,2.37) 242.72,2.52 R494.1 ; C436.2 259.88,7.41 v4(259.07,7.41) ; R493.2 v4(257.77,3.48) ; v4(241.57,5.4) 242.14,5.4 242.17,5.37 C451.1 ; C473.2 v4(251.58,2.71) ; D28.2 C421.2 v4(259.07,9.68) ; v4(241.85,6.94) 241.88,6.94 242.2,6.62 C445.2 ; C462.2 v4(254.08,3.61) ; v4(243.1,4.64) 242.95,4.49 C459.2 ; v4(241.37,2.89) 240.95,2.89 240.87,2.96 R495.1 ; R486.1 v4(251.53,3.72) ; R472.2 v4(257.87,5.64)
  vias: v4(238.32,3.03) v4(239.75,4.59) v4(241.04,4.64) v4(252.65,3.92) v4(253.51,13.05) v4(253.54,12.23) v4(254.3,10.01) v4(254.53,12.99) v4(254.5,12.26) v4(255.47,13.02) v4(261.13,9.66) v4(261.13,2.65) v4(262.63,7.96) v4(262.63,4.48) v5(262.61,10.3) v5(262.61,8.7) v5(262.6,7.04) v5(262.6,5.42) v5(262.6,3.79)
ALERT#: length 4
  BOTTOM w0.117: PR259.2 183.59,20.81 v4(183.27,21.13) 181.55,22.86 PU12.37
ALL_SYS_PWRGD: length 40.2
  TOP w0.064: PU5.G11 69.29,43 69.29,41.77
  TOP w0.102: 69.29,41.77 v2(69.39,41.67)
  GND1 w0.102: v9(68.98,41.67) v2(69.39,41.67)
  GND2 w0.127: v9(68.98,41.67) 69.28,41.67 69.54,41.93 v8(69.56,41.93)
  IN4 w0.071: v8(57.98,23.81) 58.31,24.14 58.39,24.14 63.24,28.99 63.65,28.99 64.89,30.23 65.37,30.23 67.28,32.14 67.28,32.8 68.22,33.74 68.22,38.44 69.26,39.48 69.26,41.62 v8(69.56,41.93)
  BOTTOM w0.117: R354.2 v4(49.04,18.05) C332.1 49.13,18.74 49.47,19.08 49.47,21.83 50.89,23.24 54.34,23.24 54.91,23.81 v8(57.98,23.81)
ALL_SYS_PWRGD_R: length 3.7
  BOTTOM w0.076: U17.A10 50.39,14.16 50.02,14.53 50.02,14.76 49.94,14.84
  BOTTOM w0.117: 49.94,14.84 48.96,15.82 48.96,16.69 49.04,16.77 R354.1
APU_BLEN_R: length 2.2
  BOTTOM w0.117: Q22.2 45.64,23.93 45.36,24.2 R281.1 45.36,25.12 v4(45.16,25.33)
AUXN: length 3
  BOTTOM w0.117: R10950.2 C279.2 251.71,27.67 251.66,27.62 R253.2 251.66,27.04 251.48,26.86 251.48,26.49 251.58,26.39 U13.25
AUXP: length 2.2
  BOTTOM w0.117: U13.24 251.18,26.75 251.02,26.91 R252.2 251.02,27.67 250.95,27.74 C278.2
BATDIS_G: length 26.5
  IN2 w0.508: v5(89.58,22.6) 85.38,18.4 79.95,18.4 79.67,18.12 73.64,18.12 73.11,18.64 67.31,18.64 66.62,17.95 v4(66.62,17.49)
  BOTTOM w0.203: v4(66.62,17.49) 66.37,17.74 PR277.2
BATLED0#: length 222.3
  IN3 w0.094: v8(52.44,6.64) 52.67,6.64 53.16,6.15 53.83,6.15 54.11,6.43 55.86,6.43 56.49,7.07 57.98,7.07 59.63,8.72 59.99,8.72 60.47,9.2 60.47,9.56 61.58,10.66 65.13,10.66 67.87,13.41 71.78,13.41 72.58,14.21 79.57,14.21 80.29,13.49 86.95,13.49 87.7,14.24 89.71,14.24 96.44,7.52 98.84,7.52 99.51,6.86 102.28,6.86 102.77,6.37 131.8,6.37 132.03,6.13 139.62,6.13 140.61,7.12 145.82,7.12 146,7.31 146.41,7.31 146.7,7.03 158.39,7.03 160.98,4.44 170.8,4.44 171.23,4.86 176.96,4.86 180.05,7.96 180.05,9.62 182.13,11.7 185.25,11.7 186.51,12.96 188.43,12.96 189.16,12.23 194.11,12.23 194.66,12.79 196.96,12.79 201.89,17.72 201.89,24.11 199.51,26.49 199.51,36.26 198.39,37.37 198.39,38.62 197.14,39.87 197.14,42.68 197.69,43.23 197.69,47.58 194.72,50.55 191.38,50.55 190.37,51.57 187.74,51.57 v4(187.27,51.09)
  IN4 w0.071: v4(189.38,54.11) 189.38,53.2 v4(187.27,51.09)
  BOTTOM w0.076: U17.N6 52.39,7.56
  BOTTOM w0.117: v8(52.44,6.64) 52.39,6.69 52.39,7.31 52.39,7.31 52.39,7.56 ; R158.1 182.71,51.68 v4(186.55,51.68) 186.68,51.68 v4(187.27,51.09) ; R152.1 v4(189.38,54.11)
BATLED1#: length 220.4
  IN3 w0.094: v4(186.53,51.07) 186.9,50.71 187.27,50.71 187.9,50.07 194.46,50.07 197.18,47.35 197.18,45.05 196.36,44.22 196.36,39.95 197.9,38.41 197.9,37.19 198.85,36.23 198.85,26.47 201.41,23.91 201.41,17.92 197.44,13.95 195.15,13.95 193.91,12.71 189.36,12.71 188.63,13.44 186.31,13.44 185.05,12.18 181.93,12.18 179.57,9.82 179.57,8.15 176.76,5.34 171.3,5.34 171.11,5.53 160.56,5.53 158.59,7.51 146.9,7.51 146.62,7.79 145.72,7.79 145.55,7.62 140.24,7.62 139.24,6.61 132.23,6.61 132,6.85 102.97,6.85 102.48,7.34 99.7,7.34 99.04,8 96.64,8 89.22,15.42 87.58,15.42 86.13,13.97 80.49,13.97 79.77,14.69 72.38,14.69 71.58,13.89 67.67,13.89 66.45,12.67 64.73,12.67 63.31,11.25 60.31,11.25 57.84,8.78 57.84,8.07 57.33,7.56 56.31,7.56 55.66,6.91 54.24,6.91 53.69,7.46 v8(52.9,7.46)
  IN4 w0.071: v4(186.53,51.07) 186.53,54.11 v4(186.53,54.11)
  BOTTOM w0.076: U17.N5 52.89,7.64 52.9,7.62 52.9,7.56
  BOTTOM w0.117: v4(186.53,51.07) 186.41,51.2 181.5,51.2 v4(181.05,51.65) 180.64,52.06 R157.1 ; R151.1 v4(186.53,54.11) ; 52.9,7.56 v8(52.9,7.46)
BATT+:
  vias: v4(85.29,12.78) v4(87.42,11.77)
BEEP_1: length 3.4
  BOTTOM w0.117: C356.2 v4(252.09,15.86) 252.46,15.86 252.47,15.85 C355.1 R351.2 R346.1
BI: length 82.5
  IN2 w0.094: v4(43.66,8.14) 43.66,11.18 41.13,13.71 41.13,15.15 41.12,15.16 41.12,15.7 40.86,15.96 40.86,23.05 37.59,26.32 v4(37.59,27.17)
  IN4 w0.071: v8(66.06,12.44) 60.57,6.94 59.43,6.94 57.14,4.66 52.06,4.66 50.26,6.46 49.02,6.46 48.81,6.26 46.68,6.26 45.84,7.09 44.7,7.09 v4(43.66,8.14)
  BOTTOM w0.117: BAT1.4 80.82,11.89 81.06,12.13 v4(81.06,13.16) 81.06,13.41 80.66,13.8 78.66,13.8 77.97,13.11 77.97,11.67 77.82,11.52 76.59,11.52 75.89,12.22 74.6,12.22 73.58,13.25 72.83,13.25 69.87,16.21 69.23,16.21 69.09,16.07 66.97,16.07 66.06,15.15 v8(66.06,12.44) ; v4(33.27,27.79) R240.1 PR208.1 34.41,26.86 SW2.4 35.07,25.51 35.17,25.41 37.75,25.41 37.92,25.58 SW2.3 37.92,26.84 v4(37.59,27.17)
BI_GATE: length 49.5
  IN2 w0.094: v4(39.62,30.41) 39.62,30.97 39.86,31.21 39.86,33.02 38.05,34.82 38.05,49.55 40,51.5 40,53.07 34.25,58.82 v4(32.97,58.82)
  BOTTOM w0.117: Q16.5 43.53,30.44 43.25,30.17 42.85,30.17 42.36,29.67 42.36,29.42 42.2,29.26 C277.1 ; C277.1 41.64,29.26 v4(40.49,30.41) v4(39.62,30.41) ; C277.1 41.65,28.38 41.47,28.2 Q17.2 ; v4(32.97,58.82) v4(33.99,58.82) 34.4,59.23 R141.2 36.19,60.45 SW1.2 36.84,60.87 38.96,60.87 SW1.1
BIOS_CS#: length 5.2
  BOTTOM w0.076: U17.A7 51.89,14.8 51.76,14.93
  BOTTOM w0.117: R342.1 50.79,17.89 50.79,16.45 v4(50.62,16.28) 50.62,16.08 51.76,14.94 51.76,14.93
BIOS_RD#: length 4.7
  BOTTOM w0.076: 52.45,14.93 52.45,13.97 U17.A6
  BOTTOM w0.117: R344.1 51.71,17.72 51.71,16.44 v4(51.89,16.26) 51.89,15.61 52.45,15.05 52.45,14.93
BIOS_SPI_CLK: length 3.7
  BOTTOM w0.076: 53.15,14.93 53.15,14.01 53.14,14.01 53.14,13.67 52.89,13.42 U17.B5
  BOTTOM w0.117: R357.1 52.98,16.49 v4(53.18,16.29) 53.18,14.96 53.15,14.93
BIOS_WR#: length 3.8
  BOTTOM w0.076: 52.63,14.93 52.63,13.65 U17.B6
  BOTTOM w0.117: 52.63,14.93 52.63,15.2 52.29,15.54 52.29,16.42 52.12,16.59 R356.1
BIT_CLK_AUDIO: length 183.7
  IN2 w0.094: v4(247.75,13.02) 247.27,13.5 245.33,13.5 244.86,13.03 240.77,13.03 240.15,13.64 230.99,13.64 230.08,12.73 229.09,12.73 228.15,13.68 222.59,13.68 221.51,12.59 217.93,12.59 217.83,12.69 211.89,12.69 211.41,12.21 196.79,12.21 196.41,12.59 190.4,12.59 190.12,12.31 186.1,12.31 185.44,11.65 183.31,11.65 182.6,12.36 171.58,12.36 170.81,11.59 163.58,11.59 161.33,9.34 154.41,9.34 152.75,7.68 147.03,7.68 146.66,8.06 145.69,8.06 145.31,7.68 139.61,7.68 139.08,7.15 104.35,7.15 103.97,7.53 100.58,7.53 94.54,13.56 94.54,21.11 95.42,21.99 95.42,24.45 97.05,26.09 97.05,26.38 98.29,27.62 v9(99.29,27.62)
  GND2 w0.117: v8(100,27.85) 99.77,27.62 v9(99.29,27.62)
  BOTTOM w0.117: U19.6 v4(247.75,13.02) 247.27,13.49 C370.2 ; R238.1 C283.1 101.59,27.95 101.48,27.84 v4(100.53,27.84) 100.04,27.84 100.03,27.85 v8(100,27.85)
BL#: length 9.9
  BOTTOM w0.117: Q22.3 46.24,21.7 44.98,21.7 44.37,21.09 v4(43.94,21.09) 43.64,21.38 43.64,21.91 43.33,22.23 42.06,22.23 41.8,22.49 Q21.2 41.8,23.88 42.2,24.29 R276.1 42.63,24.9 R275.1
BL_ON: length 37.9
  IN1 w0.071: v4(16.28,9.27) 16.72,9.71 21.12,9.71 24.43,13.02 24.43,14.89 25.14,15.6 38.2,15.6 v4(39.01,16.42)
  BOTTOM w0.117: R427.2 v4(16.28,9.27) ; Q21.3 42.82,20.47 42.62,20.28 42.51,20.28 42.51,20.28 R329.1 41.6,20.27 41.03,19.69 39.51,19.69 39.01,19.19 v4(39.01,18.59) D18.2 v4(39.01,16.42) 39.59,16.42 39.65,16.47 Q23.3
BLONCON: length 10.3
  BOTTOM w0.117: CN9.15 23.05,13.16 22.65,12.76 22.29,12.76 21.98,12.45 21.98,10.95 21.37,10.34 R426.1 16.74,10.34 16.73,10.33 R427.1 15.5,10.33 v4(15.49,10.32)
BOARD_ID0: length 10.5
  TOP w0.117: R80.2 102.36,40.82 102.49,40.96 R82.1 102.74,40.55 102.69,40.49 v4(102.69,40.27) 102.91,40.05 v1(103.09,40.05)
  IN1 w0.06: 110.05,40.68 110.05,41.09 110.29,41.32 v11(110.29,41.53)
  IN1 w0.071: v1(103.09,40.05) 103.29,39.84 104.48,39.84 104.52,39.87 109.61,39.87 110.05,40.32 110.05,40.68
BOARD_ID1: length 17.4
  TOP w0.117: R76.2 R71.1 100.28,42.04 100.63,41.7 100.63,40.7 v4(100.53,40.6) 100.53,40.35 100.27,40.1 100.27,38.93 v1(100.15,38.8)
  IN1 w0.06: 104.78,39.65 104.46,39.33 ; 110.79,41.32 110.78,41.33 v11(110.78,41.53)
  IN1 w0.071: 104.46,39.33 102.16,39.33 101.68,38.85 101.23,38.85 101.18,38.8 v1(100.15,38.8) ; 110.79,41.32 111.02,41.09 111.02,40.71 109.53,39.21 106.84,39.21 106.74,39.31 106.41,39.31 106.01,39.71 104.84,39.71 104.78,39.65
BOARD_ID2: length 12.5
  TOP w0.117: v1(102.69,39) R93.1 R92.2
  IN1 w0.06: v11(111.02,41.85) 111.02,41.55 111.02,41.54
  IN1 w0.071: v1(102.69,39) 102.86,39.18 104.82,39.18 105.21,38.78 105.91,38.78 106.09,38.96 107.76,38.96 108.15,38.57 108.81,38.57 109.06,38.83 109.98,38.83 110.3,39.15 110.3,39.76 111.16,40.61 111.16,41.14 111.02,41.28 111.02,41.54
BOARD_ID3: length 10.3
  TOP w0.117: R65.1 102.83,42.93 ; 102.83,42.93 102.46,42.56 v1(102.46,42.51) ; 102.83,42.93 102.36,42.93 102.31,42.89 R64.2
  IN1 w0.06: 106.22,41.44 106.48,41.17 108.76,41.17 108.97,41.38 109.14,41.38 109.2,41.33 109.38,41.33 109.46,41.41 109.52,41.41 109.82,41.71 109.82,41.99 109.88,42.05 110.22,42.05 v11(110.29,42.12)
  IN1 w0.071: v1(102.46,42.51) 102.56,42.41 102.69,42.28 102.79,42.28 103.13,41.94 105.71,41.94 106.22,41.44
BOARD_ID4: length 10
  TOP w0.117: v1(107.09,40.16) 107.09,41.73 105.63,43.2 R62.1 R56.2
  IN1 w0.06: v11(110.78,42.17) 110.71,42.1 110.66,42.1 110.57,42.01 110.49,42.01 110.26,41.78 110.26,41.78 109.93,41.46 109.93,40.96 109.92,40.94 109.92,40.68
  IN1 w0.071: v1(107.09,40.16) 108.04,40.16 108.19,40.01 109.55,40.01 109.92,40.37 109.92,40.68
BOARD_ID5: length 9.8
  TOP w0.117: R69.2 102.1,42.16 v1(102.43,41.82) 102.68,41.82 R70.1
  IN1 w0.06: 106.4,41 106.53,41 106.58,41.05 108.81,41.05 108.91,40.95 109.67,40.95 109.8,41.08 109.8,41.49 110.04,41.73 v11(110.04,41.85)
  IN1 w0.071: v1(102.43,41.82) 102.72,41.82 103.11,41.43 104.89,41.43 105.14,41.69 105.61,41.69 106.29,41 106.4,41
BOARD_ID6: length 12.1
  TOP w0.117: R57.2 104.33,43.37 104.48,43.22 104.48,42.34 104.64,42.18 105.15,42.18 105.22,42.25 R68.1 105.93,42.51 106.83,41.61 106.83,39.54 v1(106.93,39.44)
  IN1 w0.06: v11(110.57,41.81) 110.53,41.77 110.53,41.06 ; v1(106.93,39.44) 107.82,39.44
  IN1 w0.071: 110.53,41.06 110.53,40.47 109.42,39.37 107.89,39.37 107.82,39.44
BOARD_ID7: length 10.4
  TOP w0.117: v1(103.27,42.5) 103.19,42.58 103.19,43.09 103.06,43.22 102.84,43.22 102.77,43.29 R59.1 R58.2
  IN1 w0.06: v11(111.02,42.49) 110.79,42.49 110.68,42.38 110.24,42.38 110.13,42.28 109.57,42.28 109.14,42.7 108.86,42.7 108.76,42.6 108.55,42.6 108.38,42.43 106.98,42.43 106.81,42.25 106.22,42.25
  IN1 w0.071: 106.22,42.25 103.52,42.25 v1(103.27,42.5)
BQACDET: length 4.2
  BOTTOM w0.178: PR274.1 63.91,18.73 64.29,19.11 v4(64.51,19.11) 65.12,19.11 65.62,19.61 PU14.6
  BOTTOM w0.203: PR274.1 63.91,17.73 PC209.1 63.91,17.05 PR292.1
BQACDRV: length 1.6
  BOTTOM w0.178: PR277.1 66.37,19.08 66.43,19.14 PU14.4
BQACN: length 25.4
  IN3 w0.254: v8(68.3,19.34) 68.12,19.17 68.12,19.01 68.24,18.88 72.96,18.88 73.86,17.98 84.85,17.98 85.59,18.73 85.59,20.79 v4(85.45,20.93)
  BOTTOM w0.178: v8(68.3,19.34) 67.97,19.34 67.62,19.68 PU14.1
  BOTTOM w0.203: v8(68.3,19.34) 68.44,19.34 v4(68.78,19.01) 68.78,19 PC205.2 68.78,17.35 PC215.1 ; v4(85.45,20.93) 85.58,20.8 85.58,20.43 85.38,20.23 PR262.1
BQACP: length 25.8
  IN3 w0.254: v4(86.1,20.94) 85.97,20.82 85.97,18.6 85.04,17.66 73.69,17.66 72.79,18.56 68.1,18.56 67.69,18.98 v8(67.62,18.98)
  BOTTOM w0.178: v8(67.62,18.98) 67.62,19.2 67.23,19.59 PU14.2
  BOTTOM w0.203: PC214.2 68,17.41 PC205.1 68,18.7 67.72,18.98 v8(67.62,18.98) ; PR261.1 86.15,20.26 86.02,20.39 86.02,20.87 v4(86.1,20.94)
BQB_1: length 1
  BOTTOM w0.117: v4(72.97,21.01) 72.49,21.49 PC180.1
BQB_2: length 2.6
  BOTTOM w0.178: 70.76,22.66 70.32,22.66 69.79,22.13 v4(69.59,22.13) 69.04,22.13 68.98,22.08 PU14.25
BQBATDRV: length 31.1
  IN1 w0.508: v4(66.09,25.26) 66.24,25.11 66.24,24.91 66.66,24.49 67.8,24.49 68.29,24.98 72.08,24.98 72.59,25.49 81.27,25.49 82.87,23.88 82.87,21.83 84.04,20.66 84.04,16.67 82.59,15.22 81.87,15.22 v5(81.21,14.56)
  BOTTOM w0.178: v4(66.09,25.26) 66.06,25.24 66.06,25.14 66.43,24.77 PU14.18
  vias: v4(81.91,14.82)
BQBATPRES: length 19.6
  IN4 w0.071: v8(64.05,23.67) 63.82,23.67 62.83,22.68 62.83,21.06 60.13,18.36 60.13,17.79 61.33,16.59 62.53,16.59 62.73,16.39 62.73,16.09 62.95,15.86 64.58,15.86 64.94,15.5 v8(67.61,15.5)
  BOTTOM w0.117: v8(67.61,15.5) v4(67.05,15.5)
  BOTTOM w0.178: v8(64.05,23.67) PR225.1 64.28,24.74 64.37,24.65 65.1,24.65 65.23,24.53 PU14.15
BQBATSRC: length 2.3
  BOTTOM w0.178: PU14.17 66.03,24.64 65.48,25.19 v4(65.48,25.44) PR212.1
BQCLK: length 1.8
  BOTTOM w0.178: PR239.2 63,23.1 63.62,22.48 PU14.12
BQCMSRC: length 1.7
  BOTTOM w0.178: PU14.3 66.83,19.31 67.13,19.01 PR278.1
BQDATA: length 1.6
  BOTTOM w0.178: PR244.2 63.32,22.08 PU14.11
BQHIDRV: length 10
  IN4 w0.508: v5(76.8,19.73) 76.8,21 75.31,22.49 72.26,22.49 71.67,21.91 v5(70.51,21.91)
  BOTTOM w0.178: 69.94,21.68 PU14.26
  BOTTOM w0.203: 69.97,21.71 69.94,21.68
  vias: v4(77.16,19.08)
BQIADP: length 4.7
  BOTTOM w0.178: PU14.7 65.23,20.3 65.09,20.43 64,20.43 v4(63.67,20.1) 63.49,19.92 63.49,18.79 63.31,18.6 PC204.1
  BOTTOM w0.203: PC204.1 62.83,18.6 62.7,18.48 PR279.2
BQIBAT: length 4.6
  BOTTOM w0.117: PR266.2 61.86,19.36 v4(61.39,18.88)
  BOTTOM w0.178: PU14.8 63.76,20.88 63.23,20.34 63.23,20.09 63.08,19.94
  BOTTOM w0.203: PC191.1 63.08,19.94 62.81,20.21 62.3,20.21 61.86,19.77 PR266.2
BQILIM: length 3.2
  BOTTOM w0.178: PU14.21 67.62,24.49 68.16,25.03 v4(68.35,25.03) 68.46,25.14 PR215.1
  BOTTOM w0.203: PR204.1 68.34,26.39 68.46,26.26 PR215.1
BQLODRV: length 8.8
  IN2 w0.635: v5(76.32,23.82) 75.64,23.13 72.89,23.13 71.6,24.42 70.22,24.42 v5(69.69,23.89)
  BOTTOM w0.178: PU14.23 69.16,22.88 69.44,23.15
  vias: v4(69.89,24.62)
BQPHASE: length 4.5
  IN4 w0.508: v5(70.71,21.15) 72.66,21.15 v5(73.28,21.82)
  BOTTOM w0.178: 70.07,21.28 PU14.27
  BOTTOM w0.203: 70.07,21.28 70.07,21.28
  vias: v4(77.59,24.42) v4(81.53,24.39)
BQSRN: length 35.3
  IN2 w0.203: v4(66.81,25.15) 66.81,24.85 66.29,24.33 65.06,24.33 64,23.28 64,15.64 64.82,14.82 71.95,14.82 73.58,16.45 81.62,16.45 82.04,16.03 82.39,16.03 82.8,16.44 v4(82.8,16.47)
  BOTTOM w0.178: PU14.19 66.83,24.8 v4(66.81,25.15)
  BOTTOM w0.203: v4(66.81,25.15) 66.62,25.33 PC151.2 66.62,26.6 PC145.1 ; PR290.1 82.7,16.91 82.7,16.58 v4(82.8,16.47)
BQSRP: length 34.3
  IN2 w0.203: v4(82.21,16.47) 81.95,16.74 73.49,16.74 71.84,15.09 64.98,15.09 64.27,15.8 64.27,17.02 64.27,17.02 64.27,23.17 65.17,24.06 66.4,24.06 67.06,24.72 67.22,24.72 v4(67.56,25.06)
  BOTTOM w0.178: PU14.20 67.23,24.73 v4(67.56,25.06)
  BOTTOM w0.203: PC146.1 67.4,26.65 PC151.1 67.38,25.78 67.38,25.24 v4(67.56,25.06) ; PR291.1 82.29,16.93 82.29,16.55 v4(82.21,16.47)
BQTB_STAT: length 2.9
  BOTTOM w0.178: PR216.1 65.08,24.95 65.33,24.95 65.62,24.66 PU14.16
  BOTTOM w0.203: v4(63.78,25.82) 64.08,25.52 PR216.1
BQVCC:
  vias: v4(69.54,20.23)
BST_CORE:
  vias: v4(182.57,28.61)
BST_GT1:
  vias: v4(174.24,28.23)
BT_EN: length 203.4
  TOP w0.117: CN1.54 200.05,38.35 199.97,38.27 198.65,38.27 v4(198.02,37.64) 197.48,37.1 v4(196.9,37.1)
  IN3 w0.094: v4(196.9,37.1) 197.22,36.77 197.22,36.08 196.41,35.27 196.41,32.51 198.08,30.84 198.08,22.22 197.87,22.01 197.87,20.39 191.88,14.4 183.51,14.4 182.34,13.23 174.58,13.23 171.45,16.35 168.37,16.35 165.46,19.26 161.51,19.26 160.57,18.32 160.57,15.24 153.95,8.63 147.37,8.63 147.08,8.91 145.23,8.91 145.08,8.75 139.63,8.75 139.3,9.08 139.02,9.36 132.16,9.36 132.05,9.25 127.29,9.25 127.18,9.36 100.6,9.36 92.49,17.47 92.49,20.54 89.8,23.23 88.27,23.23 86.79,24.71 85.22,24.71 84.61,25.32 79.27,25.32 78.31,26.28 71.79,26.28 70.99,25.47 68.62,25.47 67.72,24.57 64.23,24.57 61.74,22.08 61.29,22.08 58.24,25.13 50.95,25.13 50.42,24.6 49.13,24.6 45.56,21.04 v8(45.56,19.78)
  BOTTOM w0.117: R339.1 45.77,19.57 v8(45.56,19.78)
BT_EN_EC: length 8.8
  BOTTOM w0.117: U17.A13 48.79,14.01 48.79,14.37 47.72,15.43 47.72,15.88 46.7,16.9 46.7,17.4 C350.1 45.77,18.34 R339.2 45.78,18.76 46.08,19.06 46.08,20.09 45.56,20.61 v4(45.56,21.04)
CATERR#: length 7.8
  IN1 w0.06: v11(122.78,47.6) 122.98,47.6 123.1,47.72 123.23,47.72 123.43,47.92 123.5,47.92 123.69,48.1 123.9,48.1 124.36,48.56 124.36,48.64 124.51,48.78 124.51,49.14 124.58,49.22 124.58,49.52 124.37,49.73
  IN1 w0.071: 124.37,49.73 124.3,49.8 124.3,51.58 123.9,51.98 v2(122.83,51.98)
  GND1 w0.117: v2(122.83,51.98) 122.58,52.24 v9(122.58,52.42)
  GND2 w0.117: v8(123.01,52.41) 123,52.42 v9(122.58,52.42)
CBN: length 1.4
  BOTTOM w0.117: C463.2 245.71,4.26 246.15,4.69 U19.35
CBP: length 5.2
  BOTTOM w0.117: U19.37 244.46,6.27 244.42,6.23 244.42,5.01 243.88,4.48 243.88,3.95 244.04,3.79 244.15,3.79 244.65,3.28 245.1,3.28 245.5,3.68 C463.1
CBTL02043A_SEL: length 21.4
  IN1 w0.071: v4(238.25,26.78) 237.64,26.17 230.64,26.17 230.2,26.61 225.04,26.61 223.31,24.88 v4(222.62,24.88)
  BOTTOM w0.117: R10989.2 237.65,27.4 237.74,27.49 238.37,27.49 v4(238.5,27.36) 238.5,27.03 v4(238.25,26.78) 238.25,26.25 238.38,26.12 U15.9 ; U40.26 v4(222.62,24.88)
CBTL02043A_XSD: length 7.2
  BOTTOM w0.117: U15.2 238.27,22.62 238.12,22.46 237.53,22.46 236.97,21.9 236.97,21.43 R372.2 R371.2 235.58,20.56 235.83,20.3 Q29.3 236.72,19.67 v4(237.1,20.05)
CC_OC#: length 4.6
  TOP w0.089: U3.B8 109.88,49.08 109.88,49.96
  TOP w0.117: 109.88,49.96 109.14,50.71 109.14,51.7 109.34,51.91 109.49,51.91 110.07,52.49 R34.1
CCG1_I2C_INT_D: length 11.6
  BOTTOM w0.117: U40.15 217.92,20.05 217.16,20.81 R416.2 217.01,20.61 216.83,20.43 216.02,20.43 215.39,21.06 214.7,21.06 v4(214.24,21.52) 213.99,21.78 213.99,22.46 213.86,22.59 213.86,24.37 213.35,24.87 212.46,24.87 212.34,25 Q25.1
CCG4_SWD_CLK: length 5.1
  BOTTOM w0.117: R10979.2 226.89,14.97 TP32.1 225.88,15.48 225.16,15.48 224.12,16.52 U40.2
CCG4_SWD_IO: length 4.1
  BOTTOM w0.117: R10978.2 226.77,15.98 TP31.1 226.38,15.86 225.42,15.86 224.62,16.66 U40.1
CCG4_XRES: length 4.3
  BOTTOM w0.117: R10990.1 C953.2 218.18,16.74 218.3,16.62 TP25.1 220.01,16.62 220.12,16.73 U40.10
CCG_I2C_INT#: length 192.6
  IN1 w0.071: v4(211.37,25.89) 211.12,25.64 207.13,25.64 205.73,24.24 199.76,24.24 197.73,22.21 197.73,21.9 v4(197.33,21.5)
  IN3 w0.094: v8(183.43,8.97) 182.24,7.78 182.24,7.47 180.43,5.66 180.43,4.4 179.22,3.19 138.21,3.19 137.51,3.89 132.61,3.89 131.26,5.25 96.66,5.25 89.57,12.34 79.83,12.34 79.08,13.09 73.25,13.09 72.45,12.29 68.34,12.29 62.82,6.78 59.25,6.78 58.58,6.11 57.42,6.11 56.68,5.37 v8(56.61,5.37) 56.2,4.96 54.48,4.96 54.25,5.19 52.22,5.19 51.99,5.42 51.99,6.04 v7(51.61,6.42)
  IN4 w0.071: v8(51.63,10.61) 52.13,10.11 52.13,9.03 51.66,8.56 51.66,7.79 51.28,7.41 51.28,6.75 v7(51.61,6.42)
  BOTTOM w0.076: v8(51.63,10.61) 51.63,13.16 U17.B7
  BOTTOM w0.117: v8(183.43,8.97) 183.43,10.95 184.66,12.18 184.66,13.83 185.92,15.09 187.24,15.09 187.83,15.68 191.33,15.68 v4(194.24,18.59) 197.1,21.44 197.28,21.44 v4(197.33,21.5) ; v4(211.37,25.89) 211.7,26.22 211.7,26.65 211.96,26.91 213.23,26.91 213.35,27.03 Q25.3 ; R483.2 v8(56.61,5.37)
CCG_I2C_SCL: length 229.2
  TOP w0.117: v2(217.42,17.25) 217.54,17.38 217.54,20.17 217.93,20.56 217.93,22.59 218.6,23.27 218.6,24.3 218.28,24.62 v4(217.62,24.62)
  GND1 w0.117: v2(217.42,17.25) 217.42,16.87 v9(217.16,16.62)
  IN3 w0.094: v8(54.68,14.19) 54.88,13.99 54.88,9.86 53.54,8.52 53.5,8.52 53.26,8.28 51.17,8.28 50.29,7.4 50.29,5.96 51.6,4.65 54.02,4.65 54.25,4.42 56.68,4.42 57.82,5.56 58.8,5.56 59.47,6.24 63.05,6.24 68.56,11.75 72.68,11.75 73.45,12.52 78.88,12.52 79.61,11.8 89.34,11.8 96.43,4.71 131.03,4.71 132.39,3.35 137.19,3.35 137.89,2.65 179.44,2.65 180.97,4.17 180.97,5.19 184.51,8.73 185.66,8.73 186,9.07 199.24,9.07 200.52,10.35 204.93,10.35 210.81,16.24 216.78,16.24 v9(217.16,16.62)
  IN4 w0.071: v8(62.25,29.43) 56.94,24.12 56.94,23.22 54.58,20.86 54.58,18.8 54.32,18.55 54.32,17.51 55.09,16.75 55.09,16.23 54.68,15.82 v8(54.68,14.19)
  BOTTOM w0.076: v8(54.68,14.19) 54.63,14.14 54.63,13.78 54.52,13.67 54.27,13.67 54.01,13.41 U17.B3
  BOTTOM w0.117: v4(217.62,24.62) 217.62,24.92 217.05,25.49 Q26.3 ; R361.2 57.5,17.05 v4(57.4,16.95) 56.89,16.44 56.89,15.92 56.71,15.74 56.71,15.7 55.25,14.24 54.73,14.24 v8(54.68,14.19)
CCG_I2C_SCL_D: length 5.3
  BOTTOM w0.117: U40.17 218.8,21.05 218.64,20.89 218.1,20.89 217.9,21.09 217.9,22.36 217.67,22.59 R399.2 217.01,23.1 217.05,23.14 Q26.4
CCG_I2C_SDA: length 239.1
  TOP w0.117: v2(216.15,17.25) 216.02,17.38 216.02,22.19 v4(215.26,22.95)
  GND1 w0.117: v2(216.15,17.25) 216.15,16.87 v9(216.4,16.62)
  IN3 w0.094: v8(55.19,13.71) 55.18,13.7 55.18,9.73 53.66,8.21 53.61,8.21 53.38,7.98 51.84,7.98 51.17,7.32 51.17,5.49 51.73,4.94 54.15,4.94 54.37,4.71 56.47,4.71 57.61,5.86 58.68,5.86 59.35,6.53 62.93,6.53 68.44,12.05 72.55,12.05 73.33,12.82 79,12.82 79.73,12.1 89.47,12.1 96.56,5 131.16,5 132.51,3.65 137.31,3.65 138.02,2.95 179.32,2.95 180.67,4.3 180.67,5.31 184.39,9.03 185.53,9.03 185.87,9.37 199.12,9.37 200.4,10.65 204.81,10.65 210.78,16.62 213.17,16.62 213.28,16.73 213.28,17.52 213.39,17.63 213.55,17.63 213.66,17.52 213.66,16.73 213.77,16.62 213.93,16.62 214.04,16.73 214.04,17.52 214.15,17.63 214.3,17.63 214.41,17.52 214.41,16.73 214.52,16.62 214.68,16.62 214.79,16.73 214.79,17.52 214.9,17.63 215.05,17.63 215.16,17.52 215.16,16.73 215.27,16.62 215.43,16.62 215.54,16.73 215.54,17.52 215.65,17.63 215.8,17.63 215.91,17.52 215.91,16.73 216.02,16.62 v9(216.4,16.62)
  IN4 w0.071: v8(55.19,13.71) 55.19,15.94 55.39,16.14 55.39,16.87 54.63,17.63 54.63,18.42 54.88,18.68 54.88,20.73 57.25,23.1 57.25,24.04 63.04,29.83 v8(63.52,29.83)
  BOTTOM w0.076: U17.B2 54.54,13.41 54.79,13.67 55.16,13.67 v8(55.19,13.71)
  BOTTOM w0.117: v8(55.19,13.71) 55.49,13.71 56.31,14.52 56.32,14.52 57.58,15.78 58.82,15.78 59.66,14.94 R386.2 ; v4(215.26,22.95) 215.75,23.45 Q26.6 ; v8(63.52,29.83) 63.77,30.08 v4(63.77,30.36) 63.77,30.56 62.48,31.86 62.48,32.11 62.1,32.49 61.72,32.49 61.46,32.24 61.46,31.1 61.1,30.73 Q6064.6
CCG_I2C_SDA_D: length 9.4
  TOP w0.117: v4(217.49,22.08) 216.63,22.94 v4(215.87,22.94) 215.13,23.68 v4(215.13,23.73)
  BOTTOM w0.117: U40.16 217.93,20.55 217.49,20.99 v4(217.49,22.08) 217.11,21.7 R414.2 ; Q26.1 215.75,25.57 215.13,24.95 v4(215.13,23.73)
CDE: length 3.3
  BOTTOM w0.117: U13.35 v4(254.45,22.7) 254.94,22.21 255.26,22.21 255.49,22.43 R302.1 R303.1
CEQ: length 4.1
  BOTTOM w0.117: U13.38 254.06,21.5 254.68,20.88 254.68,20.3 v4(254.63,20.25) 254.71,20.17 255.26,20.17 255.62,19.82 R333.1 R334.1
CFG4: length 1
  GND1 w0.127: v9(125.24,47.76) 124.91,47.76 124.78,47.63 v2(124.68,47.63)
  GND2 w0.127: v8(125.6,47.63) 125.37,47.63 v9(125.24,47.76)
CFG_RCOMP: length 1
  GND1 w0.305: v9(124.44,49.74) 124.36,49.66 v2(124.36,49.39)
  GND2 w0.305: v8(124.16,49.3) 124.16,49.46 v9(124.44,49.74)
CLK_LPC_KBC: length 71.6
  TOP w0.117: R107.1 104.01,37.1 v3(103.88,36.96)
  IN2 w0.066: v3(103.88,36.96) 101.97,36.96 101.51,37.43 99.43,37.43 98.9,36.9
  IN2 w0.094: v4(55.52,9.59) 55.44,9.67 55.44,14.66 59.01,18.23 v4(59.49,18.23) 59.49,18.61 59.81,18.93 59.81,23.6 63.44,27.24 65.42,27.24 65.88,26.78 68.65,26.78 69.13,27.27 70.83,27.27 71.27,26.83 76.02,26.83 76.99,25.87 84.45,25.87 84.58,25.74 86.68,25.74 91.19,30.25 92.76,30.25 97.66,35.16 97.66,35.81 98.75,36.9 98.9,36.9
  BOTTOM w0.076: v4(55.52,9.59) 55.46,9.65 54.63,9.65 U17.K2
  BOTTOM w0.117: v4(59.49,18.23) 59.49,17.91 v4(59.94,17.46) 60.07,17.33 R367.1
CLK_LPC_KBC_R: length 7.1
  TOP w0.117: v1(105.51,35.58) 105.25,35.58 104.77,36.05 104.77,36.17 104.36,36.58 R107.2
  IN1 w0.071: v1(105.51,35.58) 105.73,35.8 107.33,35.8 107.7,35.44 109.51,35.44 109.52,35.43 109.85,35.43 109.91,35.37 110.1,35.37 110.3,35.57 v1(110.51,35.57)
CLK_PCIE_WLANN: length 133.8
  IN2 w0.094: v4(195.4,41.82) 195.4,42.33 194.06,43.67 193.24,43.67 192.15,42.59 192.15,35.97 189.3,33.12 189.3,28.02 186,24.72 185.25,24.72 182.93,22.41 181.15,22.41 179.41,20.68 173.1,20.68 172.32,21.46 168.19,21.46 165.51,24.14 162.6,24.14 162.02,24.72 158.24,24.72 156.36,26.61 156.36,42.9 154.43,44.83 148.39,44.83 145.81,47.42 140.26,47.42 135.52,52.15 129.09,52.15 127.92,53.32 120.56,53.32 118.07,50.84 118.07,49.13 117.95,49.01 117.95,48.07 118.24,47.78 v3(118.24,47.64)
  BOTTOM w0.117: v4(195.4,41.82) 195.17,42.05 195.17,42.39 195.36,42.59 199.17,42.59 201.96,39.8 202.19,39.8 202.3,39.68 202.3,39.22 202.43,39.1 202.69,39.1 202.81,39.22 202.81,39.68 202.93,39.8 203.46,39.8 CN1.49
CLK_PCIE_WLANP: length 133.8
  IN2 w0.094: v3(118.24,48.13) 118.39,47.99 118.48,47.99 118.64,48.14 118.64,48.43 118.46,48.61 118.24,48.61 118.17,48.68 118.17,48.91 118.3,49.04 118.3,50.75 120.65,53.1 127.83,53.1 129,51.93 135.43,51.93 140.17,47.2 145.72,47.2 148.3,44.61 154.33,44.61 156.14,42.81 156.14,26.51 158.15,24.5 161.93,24.5 162.51,23.92 165.42,23.92 168.1,21.24 172.23,21.24 173.01,20.45 179.5,20.45 181.24,22.19 183.03,22.19 185.34,24.5 186.09,24.5 189.52,27.93 189.52,33.03 192.37,35.88 192.37,42.49 193.33,43.45 193.97,43.45 195.18,42.24 195.18,42.13 194.85,41.8 v4(194.63,41.8)
  BOTTOM w0.117: CN1.47 202.08,40.1 199.3,42.89 195.24,42.89 194.87,42.52 194.87,42.03 v4(194.63,41.8)
CLK_WLAN_DEBUG: length 150.1
  TOP w0.117: v1(104.77,36.56) 104.9,36.69 R112.1
  IN1 w0.071: v4(195.17,35.14) 195.02,34.98 191.77,34.98 188.68,31.89 188.68,28.71 187.95,27.99 187.95,24.45 188.95,23.46 188.95,15.14 188.34,14.54 187.91,14.54 185.23,11.86 182.93,11.86 182.67,12.12 165.17,12.12 163.44,10.4 140.61,10.4 139.97,11.03 106.57,11.03 105.26,12.34 102.49,12.34 100.84,14 100.29,14 99.47,14.82 99.47,24.1 98.06,25.5 98.06,28.51 98.84,29.29 98.84,30.75 98.95,30.86 98.95,33.05 99.7,33.79 99.94,33.79 100.03,33.88 100.03,34.52 100.25,34.74 100.25,35.41 100.95,36.12 100.95,36.2 101.14,36.39 102.49,36.39 102.71,36.61 102.94,36.61 103.4,36.15 103.78,36.15 103.98,36.35 104.15,36.35 104.35,36.56 v1(104.77,36.56)
  BOTTOM w0.117: v4(195.17,35.14) 195.62,35.59 v4(195.88,35.59) 195.99,35.7 198.05,35.7 R209.1
