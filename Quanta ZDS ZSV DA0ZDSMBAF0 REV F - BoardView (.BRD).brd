# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_WLAN_DEBUG_C: length 6.8
  BOTTOM w0.06: 203.96,34.1 203.24,34.1 203.19,34.14
  BOTTOM w0.117: 203.19,34.14 202.3,35.03 201.24,35.03 200.23,36.05 v4(199.51,36.05) 199.13,36.05 198.88,35.8 R209.2 ; CN1.71 203.96,34.1
CLK_WLAN_DEBUG_R: length 4.6
  IN1 w0.06: 107.28,36.33 107.53,36.33 107.88,35.98 109.09,35.98 109.35,36.24 v11(109.35,36.37)
  IN1 w0.071: v1(105.13,36.24) 105.21,36.33 107.28,36.33
CLKREQ_WLAN#: length 8.7
  BOTTOM w0.117: R194.1 R198.1 196.62,38.91 196.69,38.98 v4(196.91,38.98) Q12.1 200.38,38.98 200.75,38.6 CN1.53
CLKRUN#: length 81.7
  TOP w0.117: R10973.2 99.94,37.76 99.94,37.27 R110.2 100.15,36.25 100.15,35.56 v3(100.48,35.23)
  IN1 w0.071: v3(100.48,35.23) 100.48,35.31 100.78,35.62 100.98,35.62 101.24,35.36 102.75,35.36 103.01,35.62 105.22,35.62 105.54,35.93 107.39,35.93 107.75,35.58 109.24,35.58 109.55,35.89 109.95,35.89 110.02,35.82 110.1,35.82 110.11,35.81 110.83,35.81 v11(110.84,35.81)
  IN2 w0.094: v9(57.53,11.14) 57.53,12.94 58.96,14.38 63.28,14.38 63.64,14.02 72.3,14.02 73.57,15.29 81.48,15.29 81.66,15.11 85.63,15.11 87.44,16.92 89.68,16.92 91.14,18.38 91.14,23.8 90.48,24.46 90.48,26.93 91.73,28.17 93.26,28.17 98.97,33.88 99.02,33.88 100.36,35.23 v3(100.48,35.23)
  IN3 w0.094: v7(55.62,11.51) 55.9,11.23 57.43,11.23 v9(57.53,11.14)
  IN4 w0.071: v8(51.39,12.41) 51.84,11.96 55.18,11.96 v7(55.62,11.51)
CLR_CMOS: length 58.5
  IN2 w0.094: v4(88.89,29.57) 88.53,29.94 88.15,29.94 87.86,29.64 87.86,29.32 85.44,26.91 77.42,26.91 76.02,28.31 66.4,28.31 66.22,28.48 61.13,28.48 55.49,22.84 55.49,20.38 v4(50.64,15.52)
  BOTTOM w0.076: 51.24,14.93 51.39,14.78 U17.A8
  BOTTOM w0.117: 51.24,14.93 v4(50.64,15.52) ; R229.1 91.24,29.08 90.03,30.29 v4(89.72,30.29) 89.61,30.29 v4(88.89,29.57) ; R229.1 91.24,28.79 90.77,28.33 90.77,26.37 89.84,25.44 Q15.2 ; R229.1 92.27,28.91 Q14.2
CODEC_VREF: length 2.3
  BOTTOM w0.203: C472.1 249.44,3.82 249.44,4.27 248.95,4.76 U19.28
COMP_CORE: length 5.3
  BOTTOM w0.203: PU12.30 v4(182.06,25.66) 183.15,25.66 183.67,26.18 PC149.2 184.04,26.17 184.6,25.61 185.35,25.61 185.61,25.87 PC150.1
COMP_GT: length 4.5
  BOTTOM w0.203: PC183.1 172.06,21.56 PC174.1 173.37,22.29 v4(174.11,23.03) 174.34,23.26 PU12.4
COMP_SA: length 3
  BOTTOM w0.203: PC197.2 PC199.1 177.79,19.77 177.72,19.84 PU12.47
CPU_SVID_ALERT#: length 1.4
  GND1 w0.117: v2(125.38,49.03) 125.38,49.54 v9(125.29,49.62)
  GND2 w0.117: v9(125.29,49.62) 125.29,49.69 125.02,49.96 v8(125.02,50.27)
CPU_THRMTRIP#: length 2.3
  GND1 w0.117: v2(122.11,47.64) 122.43,47.64 v9(122.45,47.66)
  GND2 w0.117: v9(122.45,47.66) 122.45,47.74 v8(122.17,48.01)
  BOTTOM w0.117: v8(122.17,48.01) 122.17,48.06 122,48.23 121.8,48.23 v4(121.53,48.5) 121.33,48.7 R172.2
CPVEE: length 1.3
  BOTTOM w0.117: U19.34 246.55,4.6 246.43,4.48 C464.2
CSCOMP_GT: length 43.3
  TOP w0.203: PR20.1 171.22,49.34 171.02,49.55 169.95,49.55 168.87,48.47 165.01,48.47 163.98,47.43 163.98,42.81 166.49,40.3 166.49,25.26 v4(166.87,24.87)
  BOTTOM w0.203: PU12.6 174.88,24.06 174.76,23.93 173.62,23.93 173.01,23.32 PC163.2 171.12,23.32 PC160.1 171.12,23.13 170.86,22.88 PR240.1 170.27,22.88 169.89,22.88 169.69,23.08 PR241.2 168.94,22.67 167.4,22.67 166.87,23.2 v4(166.87,24.87)
CSI2_COMP: length 3.6
  TOP w0.305: R30.1 111.83,52.3 111.83,50.6 110.84,49.61 110.84,49.39 U3.A11
CSN_CORE: length 32.7
  TOP w0.203: PR35.1 184.25,44.39 184.04,44.19 184.04,42.36 185.24,41.16 186.96,41.16 187.93,40.19 PR21.2 188.85,40.18 189.36,39.66 189.36,35.38 188.16,34.17 188.16,31.43 187.62,30.89 187.62,24.42 187.14,23.94 v4(185.82,23.94)
  BOTTOM w0.203: v4(185.82,23.94) 185.68,24.08 PC165.1 PC164.1 183.59,24.08 182.81,24.86 PU12.32
CSN_GT1: length 26
  TOP w0.203: v4(169.54,26.15) 169.54,28.13 168.85,28.82 v4(168.85,29.7) 167.45,31.1 167.45,34.71 168.72,35.98 168.72,40.57 169.4,41.25 171.94,41.25 173.34,42.65 173.34,44.08 173.13,44.29 PR37.1
  BOTTOM w0.117: v4(169.54,26.15) 168.91,26.15 v4(168.78,26.02)
  BOTTOM w0.203: v4(169.54,26.15) 169.67,26.02 PR213.2
CSN_SA: length 63.9
  TOP w0.203: 153.11,47.92 153.54,47.49 v4(153.54,46.46) 153.54,45.35 156.69,42.2 162.74,42.2 165.35,39.59 165.35,21.2 167.14,19.41 168.46,19.41 170.95,16.91 173.81,16.91 174.2,17.3 175.59,17.3 177.23,15.65 179.7,15.65 v4(180.05,16.01) ; 153.11,47.92 152.29,47.11 PR28.2 ; 153.11,47.92 153.11,50.05 152.72,50.43 PR16.1
  BOTTOM w0.203: PU12.45 178.52,20.52 179.06,19.98 179.06,19.63 179.67,19.03 PC194.2 PC207.2 179.67,17.96 179.17,17.46 179.17,16.78 179.33,16.61 179.54,16.61 180.05,16.09 v4(180.05,16.01)
CSP_CORE: length 6.5
  BOTTOM w0.203: PR228.1 186.24,23.78 186.24,23.77 186.09,23.62 PR237.1 185.62,23.35 185.57,23.3 PC165.2 PC164.2 183.71,23.3 v4(183.15,23.86) 182.56,24.46 PU12.33
CSP_GT1: length 9.8
  TOP w0.203: v4(170.73,28.82) 171.07,29.16 171.41,29.16 171.95,28.62 v4(171.95,27.44) 171.95,26 v4(171.47,25.52)
  BOTTOM w0.203: v4(170.73,28.82) 170.86,28.82 171.04,29 PR186.2 ; v4(171.47,25.52) 171.47,25.59 171.73,25.86 PC154.1 173.57,25.86 173.77,25.66 PU12.10
CSP_GT2: length 9.5
  IN3 w0.203: v8(173.3,25.34) 172.08,25.34 171.01,24.27 168.88,24.27 168.5,24.65 168.21,24.65 167.94,24.37 v8(167.84,24.37)
  BOTTOM w0.203: v8(173.3,25.34) 173.38,25.26 PU12.9 ; v4(168.47,23.96) PR224.2 168.02,24.56 v8(167.84,24.37)
CSP_SA: length 6.2
  BOTTOM w0.203: 180.45,17.06 PC207.1 PC194.1 180.45,19.03 180.08,19.39 180.02,19.39 v4(179.6,19.82) 178.92,20.49 PU12.44 ; 180.45,17.06 180.63,17.23 PR295.2 ; 180.45,17.06 PR293.1
CSREF_GT: length 5.3
  BOTTOM w0.203: PU12.8 174.88,24.86 174.84,24.9 v4(172.87,24.9) 172.69,25.08 PC154.2 171.12,25.08 PC156.1 171.05,25.4 171,25.44 171,25.79 171.05,25.84 PR213.1
CSSUM_GT: length 12.5
  IN3 w0.203: v8(169.57,28.95) 169.57,27.29 168.94,26.67 168.94,25.02 v8(169.21,24.75)
  BOTTOM w0.203: PU12.7 v4(174.15,24.46) 173.34,24.46 172.98,24.1 PC163.1 171.12,24.1 PC160.2 171.11,24.1 170.66,24.55 169.82,24.55 169.32,24.05 ; 169.32,24.05 169.32,24.65 v8(169.21,24.75) ; 169.32,24.05 PR232.1 ; v8(169.57,28.95) 170.05,29.43 PR184.2
DAS/DSS#: length 4.2
  TOP w0.117: T29.1 41.14,37.99 40.2,37.05 40.2,35.57 40.2,35.57 40.2,35.29 40.06,35.15 CN2.10
DC-DET: length 30.9
  IN2 w0.254: v9(222.24,11.41) 223.26,11.41 223.67,11.82 225.81,11.82 226.31,12.33 227.14,12.33 228.01,11.46 230.61,11.46 231.43,12.27 233.61,12.27 234.77,11.12 234.77,10.7 235.55,9.91 243.86,9.91 v4(246.68,12.73)
  GND2 w0.254: v9(222.24,11.41) 221.86,11.79 v8(221.61,11.79)
  BOTTOM w0.203: R402.2 246.17,13.22 v4(246.68,12.73) 246.78,12.61 246.78,12.6 246.95,12.43 U19.4
DDI1_AUXN: length 168.2
  IN1 w0.06: v11(120.15,47.64) 120.15,47.42 120.43,47.14 121.54,47.14 121.86,47.46 121.86,48.3 121.66,48.5 121.41,48.5 121.08,48.83 121.08,48.96 120.74,49.3 120.74,49.3 120.73,49.31
  IN1 w0.071: 120.73,49.31 119.71,50.34 119.71,51.12 119.76,51.17 119.76,53.45 125.41,59.11 159.73,59.11 166.96,51.88 177.4,51.88 179.03,53.51 195.95,53.51 201.14,48.32 201.14,31.63 204.21,28.55 249.04,28.55 249.22,28.38 251.07,28.38 251.28,28.58 251.28,28.68 251.56,28.96 v4(251.63,28.96)
  BOTTOM w0.117: v4(251.63,28.96) 251.71,28.89 C279.1
DDI1_AUXP: length 168.2
  IN1 w0.06: v11(120.18,48.13) 120.18,47.93 120.3,47.8 120.35,47.75 120.35,47.57 120.34,47.56 120.34,47.4 120.48,47.26 121.49,47.26 121.74,47.51 121.74,48.25 121.61,48.38 121.36,48.38 120.96,48.78 120.96,48.91 120.66,49.21 120.65,49.21 120.64,49.22
  IN1 w0.071: 120.64,49.22 119.58,50.28 119.58,53.53 125.34,59.29 159.8,59.29 167.03,52.06 177.32,52.06 178.95,53.69 196.02,53.69 201.31,48.39 201.31,31.71 204.29,28.73 249.12,28.73 249.29,28.55 251,28.55 251.1,28.66 251.1,28.86 v4(250.97,28.99)
  BOTTOM w0.117: C278.1 250.95,28.96 v4(250.97,28.99)
DDI1_TXN0: length 158.6
  TOP w0.06: U3.A46 v1(121.79,49.42)
  IN1 w0.071: v1(121.79,49.42) 121.74,49.47 121.74,49.64 120.77,50.61 120.77,53.01 125.88,58.11 159.31,58.11 166.49,50.92 177.79,50.92 179.35,52.48 191.05,52.48 191.49,52.05 195.93,52.05 199.28,48.7 199.28,46.59 200.07,45.81 200.07,35.18 199.66,34.78 199.66,32.95 200.1,32.52 200.1,30.9 203.63,27.36 213.82,27.36 217.73,23.45 233.32,23.45 233.6,23.17 234.16,23.17 v4(234.56,22.77)
  IN3 w0.094: v8(242.69,18.72) 242.77,18.8 242.77,18.91 242.63,19.06 238.27,19.06 235.48,21.84 235.48,22.5 235.31,22.67 235.03,22.67 234.8,22.91 234.7,22.91 v4(234.56,22.77)
  BOTTOM w0.117: C337.1 243.83,19.16 243.75,19.08 242.74,19.08 242.69,19.03 v8(242.69,18.72)
DDI1_TXN1: length 156.1
  IN1 w0.071: v1(122.43,48.87) 122.43,49.2 122.26,49.37 122.26,49.4 122.26,49.79 121.53,50.52 121.53,51.49 121.69,51.64 121.69,52.68 126.33,57.33 158.99,57.33 166.17,50.15 178.18,50.15 179.73,51.7 190.52,51.7 192.33,49.89 194.39,49.89 194.47,49.81 195.44,49.81 195.68,49.57 197.61,47.64 197.61,45.96 199.29,44.28 199.29,38.8 198.52,38.03 198.52,32.95 198.95,32.52 198.95,29.62 202.1,26.47 213.34,26.47 217.16,22.65 227.56,22.65 228.64,21.57 237.23,21.57 v4(237.36,21.7)
  IN3 w0.094: v4(237.36,21.7) 237.61,21.44 237.79,21.44 239.19,20.05 241.36,20.05 242.17,20.85 242.89,20.85 v8(242.97,20.94)
  BOTTOM w0.117: C322.1 243.69,21.19 243.22,21.19 v8(242.97,20.94)
DDI1_TXN2: length 161.8
  IN1 w0.071: v4(244.19,26.55) 244.19,26.25 243.76,25.81 243.76,25.64 243.42,25.3 232.57,25.3 232.1,24.82 229.54,24.82 229.41,24.95 228.67,24.95 227.65,23.93 222.81,23.93 221.56,25.18 217.58,25.18 214.76,28 204.01,28 200.6,31.41 200.6,46.01 199.87,46.74 199.87,48.88 195.75,53 179.19,53 177.6,51.4 166.71,51.4 159.51,58.6 125.68,58.6 120.24,53.16 120.24,50.49 121.38,49.35 121.38,49.2 v1(121.46,49.12)
  BOTTOM w0.117: v4(244.19,26.55) 244.17,26.53 244.17,26.24 244.34,26.06 244.55,26.06 244.78,25.83 244.78,24.56 245.44,23.9 245.73,23.9 245.86,24.03 C305.1
DDI1_TXN3: length 160.3
  IN1 w0.06: v1(122.17,49.15) 122.13,49.18 122.13,49.73 122.1,49.76
  IN1 w0.071: v4(245.15,26.4) 245.18,26.38 245.18,26.33 245.79,25.72 245.79,25 245.48,24.7 244.72,24.7 244.6,24.82 237.94,24.82 235.32,22.2 230.68,22.2 230.35,22.54 228.14,22.54 227.72,22.95 217.47,22.95 213.57,26.86 202.49,26.86 199.59,29.75 199.59,32.34 199.18,32.75 199.18,35.01 199.59,35.41 199.59,44.41 197.91,46.08 197.91,47.76 195.56,50.11 194.59,50.11 194.51,50.19 192.58,50.19 190.77,52 179.55,52 177.99,50.45 166.3,50.45 159.11,57.63 126.12,57.63 121.28,52.79 121.28,50.59 122.1,49.76
  BOTTOM w0.117: C297.1 245.73,26.02 245.51,26.02 245.15,26.38 v4(245.15,26.4)
DDI1_TXP0: length 158.6
  IN1 w0.06: v1(121.81,48.87) 121.81,49.08 121.57,49.33 121.57,49.56 121.51,49.62
  IN1 w0.071: v4(234.56,23.35) 233.67,23.35 233.39,23.63 217.8,23.63 213.89,27.54 203.7,27.54 200.27,30.97 200.27,32.59 199.84,33.02 199.84,34.7 200.25,35.11 200.25,45.88 199.46,46.67 199.46,48.78 196.01,52.23 191.56,52.23 191.13,52.66 179.28,52.66 177.72,51.1 166.57,51.1 159.38,58.29 125.8,58.29 120.59,53.08 120.59,50.53 121.51,49.62
  IN3 w0.094: v8(243.07,18.78) 243.07,18.93 242.72,19.28 238.36,19.28 235.71,21.94 235.71,22.59 235.4,22.89 235.12,22.89 234.66,23.35 v4(234.56,23.35)
  BOTTOM w0.117: v8(243.07,18.78) 243.19,18.65 C351.1
DDI1_TXP1: length 156
  IN1 w0.071: v1(122.48,49.49) 122.5,49.51 122.5,49.8 121.71,50.59 121.71,51.44 121.86,51.59 121.86,52.61 126.41,57.15 158.91,57.15 166.1,49.97 178.25,49.97 179.81,51.53 190.44,51.53 192.26,49.71 194.31,49.71 194.39,49.63 195.36,49.63 195.55,49.44 197.43,47.56 197.43,45.89 199.11,44.21 199.11,38.87 198.34,38.1 198.34,32.88 198.77,32.45 198.77,29.55 202.03,26.3 213.27,26.3 217.09,22.47 227.48,22.47 228.56,21.39 237.03,21.39 v4(237.36,21.06)
  IN3 w0.094: v8(242.94,20.3) 242.94,20.48 242.79,20.63 242.26,20.63 241.45,19.83 239.09,19.83 237.7,21.22 237.52,21.22 v4(237.36,21.06)
  BOTTOM w0.117: v8(242.94,20.3) 242.94,20.48 243.35,20.89 243.72,20.89 243.83,20.78 C328.1
DDI1_TXP2: length 161.7
  IN1 w0.071: v4(243.58,26.14) 243.58,25.71 243.35,25.48 232.5,25.48 232.02,25 229.61,25 229.48,25.13 228.59,25.13 227.58,24.11 222.88,24.11 221.63,25.36 217.65,25.36 214.84,28.18 204.08,28.18 200.78,31.48 200.78,46.08 200.04,46.82 200.04,48.95 195.82,53.18 179.12,53.18 177.52,51.58 166.79,51.58 159.59,58.78 125.61,58.78 120.06,53.23 120.06,50.42 121.23,49.25 121.23,49.04 121.49,48.78 v1(121.49,48.73)
  BOTTOM w0.117: v4(243.58,26.14) 243.83,26.14 244.21,25.76 244.43,25.76 244.49,25.7 244.49,24.43 245.31,23.6 245.73,23.6 C309.1
DDI1_TXP3: length 160.3
  IN1 w0.06: 121.95,49.66 122.01,49.6 122.01,49.32 121.95,49.26 121.95,49.06 122.11,48.9 v1(122.11,48.63)
  IN1 w0.071: v4(245.18,25.82) 245.44,25.82 245.61,25.64 245.61,25.07 245.41,24.87 244.8,24.87 244.67,25 237.86,25 235.25,22.38 230.75,22.38 230.42,22.71 228.21,22.71 227.8,23.13 217.54,23.13 213.64,27.03 202.56,27.03 199.76,29.83 199.76,32.42 199.36,32.82 199.36,34.93 199.76,35.34 199.76,44.48 198.09,46.16 198.09,47.69 198.09,47.83 195.63,50.29 194.67,50.29 194.59,50.37 192.66,50.37 190.84,52.18 179.48,52.18 177.92,50.62 166.37,50.62 159.19,57.81 126.05,57.81 121.1,52.87 121.1,50.51 121.95,49.66
  BOTTOM w0.117: C301.1 245.85,25.25 245.29,25.82 v4(245.18,25.82)
DDPB_CTRLDATA: length 8.9
  TOP w0.102: 107.6,50.71 v3(108.28,50.02)
  TOP w0.117: 107.6,50.71 107.03,51.27 106.29,51.27 105.82,51.75 105.36,51.75 R28.2 104.74,52.66 104.79,52.66 105.1,52.97 R10971.2
  IN2 w0.094: v3(108.28,50.02) 108.1,49.83 108.1,48.67 109.13,47.64 109.24,47.64 109.25,47.65 v3(109.55,47.65)
DDPC_CTRLDATA: length 8.1
  TOP w0.089: v1(107.91,49.4) 107.91,49.63 107.92,49.63 107.92,49.8 107.01,50.71
  TOP w0.117: 107.01,50.71 106.58,50.71 105.74,51.54 105.3,51.54 104.59,52.26 104.08,52.26 103.82,52.52 R27.2
  IN1 w0.06: v11(109.15,48.1) 109.07,48.1 108.96,48.22 108.15,48.22
  IN1 w0.071: v1(107.91,49.4) 107.84,49.32 107.84,48.45 108.07,48.22 108.15,48.22
DDR_VTT_CTRL: length 70.6
  TOP w0.06: 121.79,33.43 121.79,33.98 122.11,34.3 U3.BN47
  TOP w0.117: v2(98.72,25.52) 98.13,25.52 95.99,27.66 95,27.66 92.39,30.27 90.66,30.27 90.27,30.67 83.76,30.67 82.41,32.02 80.73,32.02 80.11,32.65 76.54,32.65 v4(76.27,32.92) 76.09,33.09 v4(76.09,33.54) ; 121.79,33.43 121.79,32.69 121.6,32.5
  TOP w0.127: 121.6,32.5 v12(121.52,32.42)
  GND1 w0.06: v12(121.52,32.42) 121.3,32.42 v9(121.18,32.29)
  GND1 w0.127: v2(98.72,25.52) 98.85,25.64 v9(98.85,25.92)
  IN3 w0.094: v9(98.85,25.92) 99,25.76 104.82,25.76 111.35,32.29 v9(121.18,32.29)
  IN4 w0.071: v8(75.61,48.91) 75.61,47.34 75.69,47.26 75.69,45.24 76.24,44.69 76.24,44.03 75.69,43.47 75.69,35.24 76.09,34.83 v4(76.09,33.54)
DEVSLP1: length 4.4
  TOP w0.117: R88.2 R81.1 41.31,41.3 41.48,41.47 R73.1 41.02,41.7 v4(40.82,41.89) 40.56,42.15 CN2.38
DIFFOUT_GT: length 9.8
  IN3 w0.203: v8(168.9,21.93) 169.25,21.58 v8(173.88,21.58)
  BOTTOM w0.203: PR248.2 170,21.64 PR252.2 169.48,21.47 169.28,21.26 PR255.2 168.96,21.88 v8(168.9,21.93) 168.62,22.21 v4(168.47,22.21) ; v8(173.88,21.58) 174.76,22.46 PU12.2
DISABLE_KB#: length 104.1
  IN4 w0.071: v8(144.77,3.56) 144.67,3.46 141.07,3.46 139.08,5.45 127.25,5.45 127.24,5.44 103.31,5.44 103.27,5.4 103.11,5.23 96.45,5.23 94.48,7.2 94.48,9.13 91.19,12.42 80.66,12.42 79.5,13.59 68.15,13.59 67.64,13.08 60.59,13.08 59.81,13.85 v8(59,13.85)
  BOTTOM w0.117: v8(144.77,3.56) 144.77,3.61 144.95,3.79 144.95,8.39 145.56,9 146.27,9 146.5,9.22 R459.1 146.67,9.31 R460.1 ; v8(59,13.85) v4(58.43,13.85) 58.36,13.85 57.45,12.93 56.52,12.93 56.5,12.91 U17.C1
DISABLE_KB#_HUB: length 8.1
  BOTTOM w0.117: R461.2 146.73,10.19 R460.2 147.9,9.76 v4(148.48,9.18) 149.22,8.44 149.22,5.5 149.68,5.04 150.31,5.04 U20.H2
DISABLE_TP#: length 107.3
  IN4 w0.071: v8(145.1,3.56) 145.1,3.54 144.89,3.32 140.29,3.32 138.45,5.16 103.42,5.16 103.22,4.96 96.12,4.96 94,7.08 94,8.95 90.66,12.28 80.61,12.28 79.44,13.45 68.21,13.45 67.7,12.94 63.55,12.94 60.57,9.96 59.76,9.96 59.07,9.28 59.07,8.67 57.35,6.94 55.7,6.94 55.47,7.18 55.47,7.57 54.62,8.41 v8(54.39,8.41)
  BOTTOM w0.117: v8(145.1,3.56) 145.13,3.59 145.13,8.01 v4(145.44,8.32) 145.79,8.67 R466.1 146.05,8.52 146.23,8.34 146.8,8.34 147.01,8.54 R467.1
DISABLE_TP#_HUB: length 6.6
  BOTTOM w0.117: R473.2 146.7,7.96 146.83,8.09 R467.2 147.77,8.09 v4(147.9,7.96) 148.96,6.89 148.96,4.58 149.25,4.29 U20.J1
DMIC_CLK_13: length 57.4
  IN4 w0.071: v4(254.71,35.69) 254.86,35.54 255.52,35.54 256.36,34.7 256.36,33.69 255.85,33.18 253.03,33.18 250.44,30.59 250.44,28.66 249.1,27.32 247.1,27.32 246.59,27.83 242.04,27.83 241.61,27.4 239.84,27.4 239.41,27.83 232.16,27.83 230.63,26.3 230.63,23.4 230.78,23.25 230.78,23.25 230.78,22.84 232.22,21.4 232.22,20.87 234.69,18.39 236.24,18.39 236.75,17.88 244.95,17.88 v8(245.2,17.63)
  BOTTOM w0.117: CN7.7 251.98,35.6 252.14,35.44 254.45,35.44 v4(254.71,35.69)
DMIC_CLK_14: length 258.5
  IN3 w0.094: v8(245.2,16.87) 244.74,16.41 244.74,15.62 243.75,14.63 239.6,14.63 238.35,13.37 230.63,13.37 230,13.99 228.94,13.99 226.73,16.2 224.39,16.2 220.84,12.65 219.06,12.65 217.82,11.41 217.16,11.41 216.64,10.89 216,10.89 212.46,7.35 212.46,7.27 212.46,4.99 209.59,2.12 188.61,2.12 188.59,2.14 v7(188.59,2.17)
  IN4 w0.071: v7(188.59,2.17) 188.49,2.07 166.8,2.07 166.35,1.62 132.29,1.62 129.77,4.14 104.92,4.14 104.59,3.8 93.02,3.8 89.5,7.32 89.5,10.55 88.86,11.19 79.9,11.19 78.66,12.42 70.42,12.42 65.32,7.32 62.78,7.32 58.01,2.55 52.75,2.55 50.13,5.16 25.24,5.16 21.52,8.88 21.52,11.47 24.28,14.23 25.42,14.23 26.28,15.09 26.97,15.09 v4(27.1,14.96)
  BOTTOM w0.117: v4(27.1,14.96) 27.05,14.91 CN9.23
DMIC_CLK_R: length 6.8
  BOTTOM w0.117: R10954.2 244.75,16.59 244.98,16.36 C357.1 244.98,13.71 246.55,12.14 U19.3
DMIC_DAT_13: length 55.8
  IN4 w0.071: v8(243.74,17.63) 243.61,17.51 236.59,17.51 236.09,18.02 234.54,18.02 231.84,20.71 231.84,21.25 230.4,22.69 230.4,23.09 230.25,23.24 230.25,26.45 232,28.2 239.56,28.2 239.99,27.77 241.45,27.77 241.88,28.2 246.75,28.2 247.26,27.7 248.94,27.7 250.06,28.82 250.06,30.74 252.87,33.56 255.69,33.56 255.98,33.84 255.98,34.55 255.36,35.17 254.84,35.17 v4(254.71,35.03)
  BOTTOM w0.117: CN7.6 252.12,35 252.22,35.09 254.64,35.09 v4(254.71,35.03)
DMIC_DAT_14: length 255.1
  IN3 w0.094: v7(188.97,2.39) 189.09,2.51 209.42,2.51 212.07,5.16 212.07,7.1 212.07,7.51 215.64,11.09 215.64,11.41 216.15,11.92 217.76,11.92 218.89,13.05 220.67,13.05 224.22,16.6 226.89,16.6 229.1,14.39 230.19,14.39 230.81,13.77 238.18,13.77 239.44,15.02 243.58,15.02 244.34,15.79 244.34,16.27 v8(243.74,16.87)
  IN4 w0.071: v4(26.5,14.71) 25.57,13.77 24.36,13.77 21.94,11.36 21.94,9 25.39,5.54 50.29,5.54 51.56,4.27 55.9,4.27 56.38,3.79 58.72,3.79 62.81,7.88 65.14,7.88 70.06,12.8 78.85,12.8 80.08,11.57 89.02,11.57 89.88,10.71 89.88,7.48 93.18,4.18 104.43,4.18 104.76,4.51 129.96,4.51 132.47,2 166.17,2 166.62,2.44 188.92,2.44 v7(188.97,2.39)
  BOTTOM w0.117: CN9.22 26.55,14.66 v4(26.5,14.71)
DMIC_DAT_R: length 6.9
  BOTTOM w0.117: U19.2 246.15,12.05 244.62,13.58 244.62,15.17 244.31,15.48 C354.1 244.31,16.34 244.19,16.46 R10956.2 R10953.2
DNBSWON#: length 69.7
  IN2 w0.094: v4(59.65,12.58) 59.78,12.71 61.94,12.71 62.23,12.41 66.5,12.41 66.72,12.63 72.87,12.63 74.13,13.89 79.58,13.89 80.56,12.92 85.39,12.92 86.74,14.26 89.02,14.26 92.7,17.95 92.7,21.72 93.69,22.7 93.69,26.31 96.27,28.88 96.97,28.88 98.93,30.84 102.28,30.84 102.61,31.17 102.61,31.79 v9(102.94,32.12)
  GND2 w0.117: v9(102.94,32.12) 103.3,32.12 v8(103.4,32.02)
  BOTTOM w0.076: U17.D2 54.43,12.41 54.68,12.66 56.64,12.66
  BOTTOM w0.117: v8(103.4,32.02) 103.63,32.02 v4(104.01,32.39) 104.01,32.4 R224.2 ; 56.64,12.66 57.56,12.66 57.91,13.01 59.21,13.01 v4(59.65,12.58) 59.94,12.87 59.94,13.4 60.6,14.06 61.13,14.06 61.53,14.46 C364.1 R378.2
DPEQ: length 3.1
  BOTTOM w0.117: R304.1 R305.1 247.64,22.56 247.79,22.7 v4(247.86,22.7) U13.14
DPWROK: length 95.4
  TOP w0.064: 67.77,42 67.77,42.48 PU5.K12
  TOP w0.102: 67.77,42 67.87,41.9 v2(67.87,41.75)
  GND1 w0.102: v9(67.87,41.33) v2(67.87,41.75)
  IN3 w0.094: v8(105.07,31.88) 105.07,29.42 103.1,27.44 101.04,27.44 99.26,29.21 94.38,29.21 94.38,29.21 93.86,29.21 93.67,29.01 90.38,29.01 88.61,27.24 79.97,27.24 79.11,28.1 72.33,28.1 71.76,27.54 69.03,27.54 68.37,26.88 65.48,26.88 65.12,27.24 64.46,27.24 64.03,26.8 62.96,26.8 62.28,27.49 v7(62.28,28.36) ; v9(67.87,41.33) 68.2,41 68.2,40.73 v8(68.93,39.99)
  IN4 w0.071: v8(68.93,39.99) 68.93,39.76 67.92,38.75 67.92,33.83 67,32.92 67,32.26 65.26,30.51 64.77,30.51 63.61,29.34 63.09,29.34 62.28,28.53 v7(62.28,28.36) 62.1,28.36 57.7,23.96 57.7,22.89 55.82,21.01 55.82,16.06 55.57,15.82 55.57,13.27 54.92,12.61 53.91,12.61 52.88,13.65 52.11,13.65 51.85,13.91 v8(49.89,13.91)
  BOTTOM w0.117: PR158.1 68.59,39.38 68.93,39.72 v8(68.93,39.99) ; v8(105.07,31.88) 105.15,31.81 v4(105.91,31.81) 106.22,32.11 R228.1
DPWROK_EC: length 94.6
  IN3 w0.094: v8(106.53,33.83) 105.76,33.07 105.76,29.19 103.32,26.75 99.18,26.75 98.14,27.79 98.14,28.06 97.91,28.29 97.91,28.29 97.84,28.35 94.88,28.35 94.66,28.13 94.23,28.13 93.84,28.52 90.58,28.52 88.81,26.75 79.71,26.75 78.85,27.61 72.57,27.61 72.01,27.05 71.51,27.05 70.64,26.17 65.17,26.17 64.99,25.99 61.49,25.99 v7(59.89,27.59)
  IN4 w0.071: v8(54.86,16.32) 54.86,16.64 54.67,16.83 53.93,16.83 53.36,17.41 53.36,18.19 54.17,19.01 54.17,20.3 54.22,20.35 v8(54.22,20.71) 54.22,20.87 56.35,23 56.35,23.65 56.69,23.98 56.69,24.72 59.56,27.59 v7(59.89,27.59) 59.99,27.59 62.62,30.22 63.65,30.22 64.25,30.82 65.18,30.82 66.73,32.37 66.73,33.06 67.64,33.97 67.64,39.2 68.19,39.76 v8(68.19,39.99)
  BOTTOM w0.076: 54.58,14.93 54.12,14.47 54.12,14.02 54.13,14.01 54.13,13.81 53.97,13.65 53.79,13.65 53.63,13.5 53.63,13.03 53.15,12.55 53.15,12.17 U17.E5
  BOTTOM w0.117: v4(56.1,16.95) 55.96,16.81 R362.2 55.39,16.5 55.21,16.32 v8(54.86,16.32) 54.86,15.2 54.58,14.93
DPWROK_R: length 9.3
  TOP w0.06: 110.23,33.14 110.31,33.14 111.26,34.09 111.57,34.09 111.8,34.33 U3.BN15
  TOP w0.117: v2(107.16,33.38) 107.4,33.14 110.23,33.14
  GND1 w0.117: v9(106.65,33.36) 106.67,33.38 v2(107.16,33.38)
  GND2 w0.117: v8(107.11,33.37) 107.1,33.36 v9(106.65,33.36)
  BOTTOM w0.117: R228.2 R223.1 106.97,33.23 v8(107.11,33.37) 106.98,33.49 R217.2 R213.2
DRON: length 56.5
  TOP w0.203: v4(157.96,56.09) 157.37,56.68 v4(157.36,56.68) PR5.1
  IN1 w0.203: v4(157.96,56.09) 159.22,56.09 162.6,52.7 162.6,48.77 162.6,48.76 162.6,43.63 166.26,39.97 166.26,23.91 170.45,19.72 v4(170.45,19.59)
  IN4 w0.203: v4(170.45,19.59) 170.53,19.67 173.91,19.67 174.53,19.04 180.87,19.04 v4(181.67,19.84)
  BOTTOM w0.203: PR258.1 181.98,20.16 v4(181.67,19.84)
DRVHVR1:
  vias: v4(61.77,35.21) v4(65.32,36.94)
DRVHVR3:
  vias: v4(75.3,40.19)
DRVHVR4: length 3.6
  IN2 w0.508: v4(72.56,54.7) 72.56,52.06 v4(73.22,51.4)
DRVHVR5:
  vias: v4(63.8,50.2)
DRVLVR1:
  vias: v4(61.28,40.49) v4(63.8,43.19)
DRVLVR3:
  vias: v4(75.3,43.01)
DRVLVR4:
  vias: v4(76.45,47.68) v4(76.91,53.78)
DRVLVR5:
  vias: v4(65.27,47.1)
EC_A20GATE: length 4.4
  BOTTOM w0.117: T60.1 57.98,11.16 56,11.16 55.75,11.41 U17.F1
EC_AOCS: length 71.7
  IN3 w0.094: v8(46.45,15.37) 46.58,15.5 49.09,15.5 50.62,17.03 58.44,17.03 v7(58.67,16.8)
  IN4 w0.071: v7(58.67,16.8) 58.66,16.8 58.66,19.36 58.95,19.64 58.95,20.84 60.13,22.02 60.13,22.47 63.35,25.69 64.9,25.69 66.7,27.49 66.7,27.97 69.49,30.77 71.06,30.77 75.53,35.24 75.53,47.17 75.28,47.43 75.28,49.06 75.54,49.33 76.11,49.33 76.32,49.55 77.59,49.55 78.35,50.31 80.74,50.31 81.25,49.8 87.73,49.8 88.18,49.34 v8(88.18,48.99)
  BOTTOM w0.117: v8(46.45,15.37) 45.94,14.87 R10960.2 ; PR70.2 88.29,50.76 v4(87.98,50.45) 87.98,49.91 88.18,49.71 v8(88.18,48.99)
EC_CE#: length 43.6
  TOP w0.109: R1.1 46.02,41.69 44.9,41.69 44.72,41.51 43.99,41.51 43.91,41.59 v3(43.91,41.71)
  IN2 w0.081: v3(43.91,41.71) 43.63,41.43 43.63,40.98 44.29,40.32 46.43,40.32 48.3,38.44 48.3,36.51 47.26,35.47 47.26,33.05 47.18,32.97 46.66,32.97 46.58,32.89 46.58,32.73 46.66,32.65 47.18,32.65 47.26,32.57 47.26,32.4 47.18,32.32 46.66,32.32 46.58,32.24 46.58,32.08 46.66,32 47.18,32 47.26,31.92 47.26,31.75 47.18,31.67 46.66,31.67 46.58,31.59 46.58,31.43 46.66,31.35 47.18,31.35 47.26,31.27 47.26,30.69 50.93,27.02 50.93,26.91 50.49,26.46 50.49,26.35 50.6,26.23 50.72,26.23 51.16,26.68 51.28,26.68 51.39,26.56 51.39,26.45 50.92,25.98 50.92,25.86 51.04,25.75 51.15,25.75 51.62,26.22 51.74,26.22 52.39,25.56 52.39,25.33 52.31,25.25 51.45,25.25 51.37,25.17 51.37,25.01 51.45,24.93 52.31,24.93 52.39,24.84 52.39,24.68 52.31,24.6 51.57,24.6 51.49,24.52 51.49,24.36 51.57,24.28 52.31,24.28 52.39,24.19 52.39,24.03 52.31,23.95 51.95,23.95 51.87,23.87 51.87,23.71 51.95,23.62 52.31,23.62 52.39,23.54 v4(52.39,20.89)
  BOTTOM w0.102: v4(52.39,20.89) 52.02,20.52
  BOTTOM w0.109: 52.02,20.52 51.4,19.9 51.4,19.34 51.25,19.18 R342.2
EC_FPBACK#: length 12.2
  IN4 w0.071: v4(42.28,16.75) 42.28,16.36 43.25,15.4 44.42,15.4 44.75,15.73 45.21,15.73 46.25,14.69 47.26,14.69 48.54,13.41 v8(49.89,13.41)
  BOTTOM w0.117: v4(42.28,16.75) 42.28,17.13 42.08,17.33 41.29,17.33 40.84,17.79 Q23.2
EC_MAINON: length 179.8
  IN3 w0.094: v4(183.19,15.9) 183.51,15.57 185.04,15.57 185.6,16.13 185.6,16.54 186.13,17.08 193.11,17.08 195.07,19.03 195.07,20.61 195.94,21.48 v8(196.41,21.48)
  IN4 w0.071: v8(52.39,9.41) 52.39,7.28 52.03,6.92 52.03,5.41 52.53,4.91 57.04,4.91 59.38,7.25 60.55,7.25 62.07,8.77 62.07,9.79 64.95,12.66 67.81,12.66 68.32,13.17 79.11,13.17 80.35,11.94 90.34,11.94 93.59,8.7 93.59,6.91 95.81,4.68 103.33,4.68 103.54,4.89 138.23,4.89 140.3,2.82 174.41,2.82 v8(174.62,3.03)
  BOTTOM w0.117: v8(196.41,21.48) 196.72,21.78 196.72,23.6 196.41,23.91 PR230.1 ; v8(174.62,3.03) 174.63,3.04 174.63,4.18 175.63,5.19 175.63,7.98 v4(175.25,8.36) 175,8.62 175,10.5 175.05,10.55 175.27,10.55 PR235.2 175,11.04 175,15.02 175.23,15.24 179.49,15.24 179.84,14.89 183.04,14.89 183.18,15.04 183.18,15.9 v4(183.19,15.9) 183.18,15.9 PR297.1
EC_MISO: length 41.8
  TOP w0.109: R10.1 47.95,42.27 47.06,42.27 46.17,41.38 45.05,41.38 44.88,41.21 44.04,41.21 v3(43.94,41.1)
  IN2 w0.081: v3(43.94,41.1) 44.39,40.65 46.39,40.65 48.62,38.41 48.62,36.47 47.79,35.63 47.79,30.55 52.8,25.53 52.8,25.13 52.88,25.05 53.58,25.05 53.66,24.97 53.66,24.81 53.58,24.72 52.88,24.72 52.8,24.64 52.8,24.48 52.88,24.4 53.58,24.4 53.66,24.32 53.66,24.16 53.58,24.07 52.88,24.07 52.8,23.99 52.8,23.83 52.88,23.75 53.58,23.75 53.66,23.67 53.66,23.51 53.58,23.42 52.88,23.42 52.8,23.34 52.8,23.18 52.88,23.1 53.58,23.1 53.66,23.02 53.66,22.85 53.58,22.77 52.88,22.77 52.8,22.69 52.8,22.53 52.88,22.45 53.58,22.45 53.66,22.37 53.66,22.2 53.58,22.12 52.88,22.12 52.8,22.04 52.8,21.22 v4(53.23,20.78)
  BOTTOM w0.109: v4(53.23,20.78) 52.95,20.78 51.78,19.62 51.78,18.91 R344.2
EC_MOSI: length 45.3
  IN2 w0.081: v3(42.89,49.92) 42.41,49.92 39.69,47.2 39.69,35.59 42.77,32.51 42.77,28.51 45.76,25.52 45.76,25.38 45.5,25.12 45.5,24.99 45.59,24.89 45.73,24.89 45.99,25.15 46.12,25.15 46.22,25.06 46.22,24.92 45.96,24.66 45.96,24.53 46.05,24.43 46.19,24.43 46.45,24.69 46.58,24.69 46.73,24.54 46.73,24.43 46.49,24.19 46.49,24.07 46.6,23.96 46.72,23.96 46.96,24.2 47.07,24.2 47.19,24.08 47.19,23.97 46.95,23.73 46.95,23.61 47.06,23.5 47.18,23.5 47.42,23.74 47.53,23.74 47.65,23.62 47.65,23.51 47.41,23.27 47.41,23.15 47.52,23.04 47.64,23.04 47.88,23.28 48,23.28 48.36,22.92 49.5,22.92 51.1,21.32 51.1,20.99 52.27,19.82 v4(52.27,19.16)
  BOTTOM w0.102: 52.48,19.37 v4(52.27,19.16)
  BOTTOM w0.109: v4(52.27,19.16) 52.55,18.88 52.55,17.86 52.12,17.43 R356.2 ; 52.48,19.37 52.62,19.51 v4(52.62,19.67)
EC_NBSWON#: length 45.1
  GND1 w0.06: v2(68.02,46.73) v9(68.02,47.08)
  GND2 w0.127: v9(68.02,47.08) v7(67.73,46.79)
  IN4 w0.071: v8(52.55,15.69) 53,16.14 53,18.11 53.99,19.11 53.99,21.11 55.68,22.8 55.68,24.4 56.23,24.95 56.64,24.95 59.54,27.86 60,27.86 62.5,30.36 63.54,30.36 64.16,30.98 65.14,30.98 66.59,32.43 66.59,33.12 67.5,34.02 67.5,39.35 67.96,39.81 67.96,40.91 67.56,41.31 67.56,42.46 68.17,43.06 68.17,46.34 v7(67.73,46.79)
  BOTTOM w0.076: U17.A5 52.89,14.93
  BOTTOM w0.117: 52.89,14.93 52.89,15.27 52.55,15.61 v8(52.55,15.69) 52.55,17.47 53,17.92 R345.2
EC_PCIE_WAKE#: length 1.9
  BOTTOM w0.117: R199.2 191.87,37.32 192.07,37.12 192.07,36.69 R10976.2 192.07,36 v4(192.14,35.92)
EC_PCIE_WAKE#_R: length 195.4
  IN3 w0.094: v8(50.13,15.68) 51.32,16.87 58.08,16.87 60.18,14.76 62.43,14.76 62.63,14.97 66.36,14.97 66.54,15.15 69.82,15.15 70.07,15.4 70.07,16.21 70.4,16.54 71.42,16.54 71.95,16.01 79.5,16.01 79.88,16.39 81.73,16.39 82.11,16.01 85.62,16.01 87.22,17.61 89.27,17.61 97.61,9.28 99.74,9.28 100.29,8.72 126.69,8.72 126.8,8.61 132.41,8.61 132.52,8.72 138.76,8.72 139.36,8.11 145.36,8.11 145.52,8.27 146.82,8.27 147.1,7.99 156.64,7.99 157.2,8.55 157.2,8.55 157.45,8.8 157.97,8.8 160.76,6.01 171.36,6.01 171.55,5.82 174.65,5.82 175.16,6.33 175.16,6.77 178.58,10.19 179.26,10.19 181.73,12.66 184.85,12.66 186.11,13.92 192.11,13.92 198.35,20.17 198.35,21.81 198.56,22.02 198.56,33.6 v4(197.17,34.99)
  BOTTOM w0.076: 50.68,14.93 50.9,14.71 50.9,14.52 51.13,14.29 51.13,13.67 U17.B8
  BOTTOM w0.117: R10976.1 191.62,35.23 192.3,34.55 195.88,34.55 196.07,34.74 196.92,34.74 v4(197.17,34.99) ; R321.2 51.15,20.75 50.87,20.46 50.87,19.74 v4(50.74,19.62) 50.46,19.34 50.46,16.8 50.06,16.39 50.06,15.76 v8(50.13,15.68) 50.13,15.48 50.68,14.93
EC_PECI: length 102.4
  IN1 w0.071: v1(122.74,48.19) 122.7,48.22 122.7,49.4 122.7,49.4 122.7,50.09 122.4,50.4 v2(122.4,51.14)
  GND1 w0.117: v2(122.4,51.14) 122.12,51.14 122.09,51.17 v9(122.07,51.17)
  IN3 w0.094: v9(122.07,51.17) 122.04,51.2 v7(120.72,51.2)
  IN4 w0.071: v7(120.72,51.2) 120.02,51.9 119.21,51.9 118.97,52.14 118.97,52.97 118.23,53.71 118.23,53.91 115.26,56.88 114.22,56.88 114.06,56.73 104.73,56.73 104.12,57.34 101.14,57.34 100.43,56.62 98.47,56.62 94.69,52.84 90.2,52.84 89.44,53.6 84.57,53.6 84.23,53.94 83.27,53.94 83.09,53.76 80.88,53.76 77.15,50.03 75.63,50.03 75.42,49.81 75.42,49.59 75,49.18 75,47.32 75.26,47.06 75.26,35.35 70.95,31.04 69.38,31.04 66.43,28.09 66.43,27.6 64.79,25.97 63.24,25.97 59.86,22.58 59.86,22.15 58.64,20.94 58.64,19.74 58.37,19.47 58.37,15.6 v8(58.77,15.2)
  BOTTOM w0.117: v4(58.29,15.37) 58.46,15.2 v8(58.77,15.2) 58.77,15.01 58.78,15 R387.2
EC_PWROK: length 105.9
  TOP w0.117: v4(99.61,32.35) 98.55,33.41 98.55,35.78 99.18,36.41 99.18,37.37 98.93,37.63 98.93,38.2 98.57,38.56 98.57,40.48 97,42.05 97,43.7 96.72,43.97 96.72,44.38 97.4,45.07 v4(97.4,45.32) 97.4,45.57 97.17,45.8 97.17,47.33 96.16,48.34 96.16,50.55 96.67,51.07 R40.1 97.05,51.07 U2.2
  IN2 w0.094: v4(50.67,7.17) 50.92,7.42 54.1,7.42 54.63,6.89 56.97,6.89 58.7,8.62 58.7,12.31 59.43,13.03 62.03,13.03 62.36,12.71 63.91,12.71 64.13,12.93 72.75,12.93 74.01,14.19 79.79,14.19 80.77,13.22 85.27,13.22 86.62,14.56 88.89,14.56 92.41,18.07 92.41,21.84 93.39,22.83 93.39,26.43 96.15,29.18 96.85,29.18 99.64,31.97 99.64,32.32 v4(99.61,32.35)
  BOTTOM w0.117: R227.1 108.25,31.84 108.24,31.84 108.24,31.7 107.34,30.8 100.3,30.8 99.95,31.15 v4(99.95,31.64) 99.95,32.04 99.64,32.35 v4(99.61,32.35) ; U17.N7 51.88,7.9 51.88,7.01 51.78,6.92 51.4,6.92 51.15,7.17 v4(50.67,7.17) 50.67,5.8 50.79,5.67 R478.1
EC_RCIN#: length 71.6
  TOP w0.117: v3(99.82,33.56) 99.35,33.56 v4(99.25,33.66) R10975.2 99.5,34.63 100.14,34.63 100.39,34.88 100.96,34.88 101.12,35.04 R118.1 R114.2
  IN2 w0.094: v4(57.2,8.14) 58.4,9.35 58.4,10.76 58.19,10.97 58.19,12.87 59.19,13.88 62.03,13.88 62.59,13.32 63.67,13.32 63.88,13.53 72.5,13.53 73.78,14.8 80.09,14.8 80.83,14.05 85.27,14.05 86.94,15.73 89.22,15.73 91.79,18.29 91.79,22.06 92.8,23.07 92.8,26.67 95.9,29.78 96.6,29.78 98.7,31.87 98.7,32.57 99.68,33.56 v3(99.82,33.56)
  BOTTOM w0.076: 56.57,8.48 56.14,8.91 55.25,8.91 55.01,8.67 54.29,8.67 54.12,8.84 54.12,9.9 53.6,10.41 U17.H4
  BOTTOM w0.117: 56.57,8.48 56.91,8.14 v4(57.2,8.14)
EC_RSMRST#: length 71.6
  IN2 w0.094: v4(59.41,13.45) 62.04,13.45 62.47,13.02 63.8,13.02 64,13.23 72.63,13.23 73.89,14.49 79.97,14.49 80.95,13.51 85.15,13.51 87.07,15.43 89.34,15.43 92.11,18.2 92.11,21.96 93.1,22.95 93.1,26.55 96.02,29.48 96.73,29.48 98.99,31.75 98.99,32.31 v4(99.61,32.93)
  BOTTOM w0.117: v4(99.61,32.93) 99.92,33.24 99.92,34.63 100.33,35.04 v4(100.99,35.04) 101.82,35.87 R207.1 ; v4(59.41,13.45) 60.07,14.12 60.2,14.12 60.7,14.61 v4(60.7,14.97) 60.7,15.3 60.27,15.73 60.27,15.82 R373.2 59.68,15.63 59.35,15.63 58.93,16.06 57.47,16.06 55.4,13.99 54.96,13.99 U17.A1
EC_SCK: length 41.9
  TOP w0.102: 44.45,50.02 44.39,49.97 R16.1
  TOP w0.109: 44.45,50.02 v4(44.9,50.48) ; v3(43.28,48.27) 43.99,48.98 43.99,49.69 44.16,49.86 R16.1
  IN2 w0.081: v4(53.28,19.72) 52.85,19.72 51.45,21.11 51.45,21.47 49.55,23.38 48.51,23.38 43.28,28.61 43.28,32.48 40.1,35.65 40.1,45.09 v3(43.28,48.27)
  BOTTOM w0.109: v4(53.28,19.72) 53.44,19.56 53.44,18.22 53.38,18.17 53.38,17.74 52.98,17.34 R357.2
EC_SMB1_CLK: length 48.5
  IN3 w0.094: v8(87.34,29.27) 87.23,29.16 86.29,29.16 85.72,28.59 81.39,28.59 80.51,29.47 71.82,29.47 71.22,28.86 v7(68.32,28.86)
  IN4 w0.071: v7(68.32,28.86) 68.32,28.12 64.93,24.72 63.74,24.72 63.14,24.12 62.51,24.12 v8(62,23.6)
  BOTTOM w0.117: R337.1 54.02,21.72 53.79,21.95 53.79,21.95 53.72,22.03 53.72,22.34 54.2,22.82 54.38,22.82 55.05,23.49 61.88,23.49 v8(62,23.6) ; R337.1 Q6072.1 ; R337.1 v4(54.93,21.06) 54.68,20.81 R330.2 54.68,19.74 54.4,19.46 R341.2 ; v8(87.34,29.27) 87.14,29.27 86.28,28.4 86.28,27.03 87.23,26.08 U9.10
EC_SMB1_DATA: length 49.4
  IN3 w0.094: v7(68.29,29.24) 68.29,29.5 69.23,30.44 71.14,30.44 71.82,29.77 81.4,29.77 81.62,29.55 82.7,29.55 82.8,29.45 82.8,29.32 82.71,29.23 81.55,29.23 81.45,29.13 81.45,28.99 81.55,28.89 85.6,28.89 86.3,29.59 87.36,29.59 87.65,29.3 v8(87.65,29.01)
  IN4 w0.071: v7(68.29,29.24) 68.05,28.99 68.05,28.23 64.89,25.08 63.05,25.08 61.36,23.38 61.36,23.34 v8(61.18,23.17) 60.55,22.53 60.55,21.85 v8(59.38,20.68)
  BOTTOM w0.117: R323.2 55.95,19.25 R314.2 55.95,20.1 56.79,20.94 58.69,20.94 v4(58.74,20.89) 58.95,20.68 v8(59.38,20.68) ; U9.9 87.18,26.58 86.71,27.05 86.71,28.28 87.37,28.95 87.47,28.95 87.54,29.01 v8(87.65,29.01) ; Q6072.4 R332.1 61.04,23.02 v8(61.18,23.17)
EC_SYS_PWROK: length 32.5
  TOP w0.117: R42.1 101.15,50.12 100.85,50.42 v1(100.11,50.42)
  IN1 w0.071: v1(100.11,50.42) 99.8,50.73 98.19,50.73 96.76,49.3 96.76,46.93 97.66,46.03 100.2,46.03 v2(100.43,46.26)
  GND1 w0.117: v9(100.76,46.24) 100.73,46.26 v2(100.43,46.26)
  GND2 w0.117: v7(101.06,46.08) 100.91,46.24 v9(100.76,46.24)
  IN4 w0.071: v8(102.51,31.3) 102.51,36.28 100.77,38.02 100.77,44.81 100.84,44.88 100.93,44.97 100.93,45.47 101.06,45.6 v7(101.06,46.08)
  BOTTOM w0.117: R501.1 v4(104.74,31.3) v8(102.51,31.3)
EC_VSTBY_FSPI: length 5.1
  BOTTOM w0.117: v4(185.03,14.82) 184.42,14.21 PD2.2 PC228.1 PR315.2 182.76,12.81 182.88,12.68 PU16.5
EC_WRST: length 87.9
  IN3 w0.094: v4(63.19,16.22) 63.24,16.27 63.24,17 62.83,17.41 62.83,18.02 61.21,19.64 60.17,19.64 57.12,22.69 53.9,22.69 v7(53.36,23.23) 53.16,23.43 51.84,23.43 51.41,23 49.52,23 v8(49.27,23.25)
  IN4 w0.071: v7(53.36,23.23) 54.59,24.46 54.59,25.77 56.99,28.18 58.03,28.18 61.43,31.58 61.43,32.19 61.69,32.45 64.52,32.45 65.13,33.07 65.13,33.72 65.74,34.32 65.74,35.31 65.56,35.49 65.56,37.76 65.13,38.19 65.13,42.53 63.9,43.75 63.9,48.18 65.87,50.15 66.09,50.15 67.77,51.83 69.27,51.83 v8(69.39,51.95)
  BOTTOM w0.076: 56.64,8.87 56.44,9.07 55.04,9.07 U17.L1
  BOTTOM w0.117: v8(69.39,51.95) 69.51,52.08 69.51,52.33 70.33,53.14 71.95,53.14 72.65,52.45 PR67.2 ; v8(49.27,23.25) 48.93,23.59 48.93,25.06 47.3,26.69 v4(47.3,27.16) 47.3,27.45 46.5,28.25 46.38,28.25 45.89,28.74 45.63,28.74 44.18,30.19 Q16.6 ; 56.64,8.87 56.83,8.68 57.25,8.68 57.51,8.94 60.08,8.94 61.01,9.86 v4(61.01,10.26) 61.01,10.61 D22.2 63.97,13.58 R384.2 63.97,15.13 63.79,15.31 C359.1 63.79,15.62 v4(63.19,16.22)
EC_WRST_R: length 9.1
  TOP w0.089: PU5.J3 68.78,47.49 68.78,49.11 68.22,49.68
  TOP w0.117: v2(68.19,49.7) 68.2,49.7 68.22,49.68
  GND1 w0.14: v2(68.19,49.7) 68.35,49.85 v9(68.35,50.35)
  IN3 w0.094: v9(68.35,50.35) 68.35,50.73 69.28,51.66 v8(71.39,51.66)
  BOTTOM w0.117: PR67.1 72.19,52.06 PR68.1 ; PR68.1 71.66,51.93 v8(71.39,51.66) ; PR68.1 v4(71.66,52.73)
EDP_AUXN: length 114.6
  TOP w0.06: U3.J42 120.5,47.44 v11(120.54,47.48)
  IN1 w0.06: v11(120.54,47.48) 120.68,47.62 120.68,47.7 120.72,47.74 120.72,48.12 120.11,48.73 119.66,48.73 119.33,49.07
  IN1 w0.071: 119.33,49.07 117.95,50.44 117.95,52.97 115.34,55.59 98.73,55.59 93.93,50.79 93.93,44.89 93.16,44.12 92.6,44.12 90.9,42.43 88.21,42.43 83.82,38.03 83.82,37.35 83.82,36.36 82.2,34.74 81.39,34.74 80.38,33.74 80.38,32.39 80.46,32.32 80.46,31.88 79.96,31.38 75.33,31.38 74.45,32.26 71.21,32.26 70.8,31.85 68.43,31.85 66.35,29.76 63.07,29.76 62.73,29.42 56.3,29.42 55.49,28.61 51.18,28.61 50.63,29.16 48.94,29.16 48.1,30.01 46.47,30.01 45.1,28.64 45.1,25.61 42.06,22.57 42.06,21.66 40.71,20.31 38.7,20.31 38.59,20.42 38.59,20.69 38.73,20.83 v4(38.8,20.83)
  BOTTOM w0.117: C325.1 38.22,20.04 38.59,20.42 38.59,20.62 v4(38.8,20.83)
EDP_AUXN_C: length 21.3
  BOTTOM w0.117: CN9.9 20.05,14.39 19.95,14.49 19.95,16.1 24.33,20.48 28.17,20.48 28.31,20.34 35.83,20.34 36.01,20.52 36.39,20.52 36.52,20.39 36.52,20.13 C325.2
EDP_AUXP: length 114.7
  IN1 w0.06: 119.24,48.97 119.24,48.97 119.25,48.97 119.28,48.94 119.28,48.94 119.61,48.61 120.06,48.61 120.6,48.07 120.6,47.99 v11(120.5,47.89)
  IN1 w0.071: 119.24,48.97 117.82,50.39 117.82,51.05 117.77,51.09 117.77,52.9 115.26,55.41 98.81,55.41 94.11,50.71 94.11,44.82 93.24,43.95 92.67,43.95 90.97,42.25 88.28,42.25 84,37.96 84,37.28 84,36.29 82.27,34.56 81.46,34.56 80.56,33.66 80.56,32.47 80.64,32.39 80.64,31.81 80.03,31.2 75.26,31.2 74.37,32.08 71.28,32.08 70.87,31.67 68.51,31.67 66.42,29.58 63.15,29.58 62.81,29.24 56.37,29.24 55.56,28.43 51.1,28.43 50.55,28.98 48.87,28.98 48.02,29.83 46.54,29.83 45.28,28.57 45.28,25.54 42.24,22.5 42.24,21.59 40.78,20.13 38.63,20.13 38.41,20.35 38.41,20.69 38.27,20.83 v4(37.84,20.83)
  BOTTOM w0.117: v4(37.84,20.83) 38.19,20.83 38.3,20.73 38.3,20.54 38.09,20.34 37.6,20.34 37.53,20.41 37.3,20.41 37.21,20.5 C317.1
EDP_AUXP_C: length 21.3
  BOTTOM w0.117: CN9.8 19.55,14.41 19.65,14.51 19.65,16.23 24.21,20.78 28.29,20.78 28.44,20.63 35.7,20.63 35.88,20.82 36.32,20.82 C317.2
EDP_HPD: length 129.8
  TOP w0.06: v2(109.56,49.85) 109.65,49.76 U3.A7
  IN1 w0.071: v4(15.17,7.3) 15.17,9.07 16.2,10.09 21.06,10.09 24.23,13.26 24.23,15.04 25.01,15.83 36.03,15.83 37.22,17.01 39.74,17.01 45.99,23.27 45.99,25.34 47.12,26.47 58.07,26.47 58.25,26.47 59.1,27.32 63.58,27.32 64.06,27.8 67.4,27.8 68.11,28.51 72.32,28.51 73.19,29.38 80.86,29.38 85.66,34.18 88.5,34.18 88.67,34 88.95,34 89.13,33.82 91.59,33.82 93.38,35.61 93.38,36.01 93.62,36.25 93.62,40.92 94.88,42.18 v2(94.91,42.18)
  GND1 w0.127: v9(94.51,42.81) 94.58,42.74 94.58,42.43 94.84,42.18 v2(94.91,42.18) ; v9(109.88,50.1) 109.85,50.1 109.6,49.85 v2(109.56,49.85)
  IN3 w0.094: v9(94.51,42.81) 96.16,44.47 96.16,49.6 97.08,50.52 102.59,50.52 105.07,53.01 107.54,53.01 108.39,52.16 108.39,50.69 108.86,50.22 109.76,50.22 v9(109.88,50.1)
  BOTTOM w0.117: R443.2 16.21,8.2 R442.1 16.16,7.31 C442.2 v4(15.17,7.3)
EDP_HPD_R: length 11
  BOTTOM w0.117: CN9.18 24.55,13.26 23.87,12.58 22.36,12.58 22.16,12.38 22.16,10.87 19.94,8.65 v4(17.58,8.65) R443.1
EDP_RCOMP: length 0.9
  GND1 w0.127: v2(123.07,49.39) 123.07,49.6 v9(123.19,49.72)
  GND2 w0.127: v8(123.14,49.22) 123.14,49.66 v9(123.19,49.72)
EDP_TX_PWM: length 6.8
  BOTTOM w0.117: CN9.11 21.05,13.48 20.77,13.19 17.4,13.19 R408.2 v4(15,12.66)
EDP_TXN0: length 115.6
  IN1 w0.06: v1(121.49,47.59) 121.49,47.77 121.09,48.16 121.09,48.3 120.67,48.71 120.67,48.75 120.67,48.75
  IN1 w0.071: 120.67,48.75 118.99,50.43 118.99,51.1 118.94,51.15 118.94,53.18 115.74,56.38 104.96,56.38 104.28,57.06 102.05,57.06 101.36,56.37 98.16,56.37 93.15,51.36 93.15,47.18 91.59,45.62 91.59,44.26 90.99,43.66 88.32,43.66 81.95,37.28 81.95,36.7 81.95,36.48 78.57,33.11 77.93,33.11 77.35,32.53 75.28,32.53 74.77,33.04 70.83,33.04 70.2,33.67 69.05,33.67 65.92,30.54 56.32,30.54 55.17,29.39 51.5,29.39 50.95,29.94 49.27,29.94 48.42,30.79 46.02,30.79 41.72,26.49 41.72,23.82 39.89,21.98 39.16,21.98 38.86,22.29 38.86,22.48 v4(38.63,22.71)
  BOTTOM w0.117: C308.1 35.63,21.74 37.38,21.74 37.81,22.17 38.68,22.17 38.89,22.39 38.89,22.55 38.74,22.71 v4(38.63,22.71)
EDP_TXN0_C: length 21.2
  BOTTOM w0.117: CN9.5 18.05,14.46 18.15,14.56 18.15,16.05 24.41,22.3 29.26,22.3 29.48,22.09 34.24,22.09 C308.2
EDP_TXN1: length 114.6
  IN1 w0.06: v1(121.17,47.49) 121.13,47.49 120.85,47.77 120.85,48.18 119.83,49.2 119.67,49.2 118.43,50.44
  IN1 w0.071: v4(40.45,20.85) 40.21,20.85 40.13,20.94 40.13,21.29 43.81,24.98 43.81,27.9 46.22,30.31 48.22,30.31 49.07,29.46 50.75,29.46 51.3,28.91 55.36,28.91 56.52,30.06 66.16,30.06 69.22,33.13 70.05,33.13 70.62,32.56 74.57,32.56 75.08,32.05 77.55,32.05 78.13,32.63 78.77,32.63 82.42,36.28 82.42,37.07 88.53,43.18 91.19,43.18 92.07,44.06 92.07,45.43 93.63,46.98 93.63,51.12 98.4,55.89 103.48,55.89 103.48,55.9 115.49,55.9 118.38,53 118.38,51.09 118.43,51.05 118.43,50.44
  BOTTOM w0.117: v4(40.45,20.85) 40.38,20.93 40.38,22.8 39.71,23.47 37.72,23.47 37.41,23.16 37.34,23.16 C304.1
EDP_TXN1_C: length 24.9
  BOTTOM w0.117: CN9.2 16.55,14.38 16.66,14.49 16.66,16.03 23.95,23.32 36.1,23.32 C304.2
EDP_TXP0: length 115.5
  IN1 w0.06: 120.79,48.81 120.79,48.76 121.21,48.35 121.21,48.21 121.37,48.05 121.46,48.05 v1(121.51,48.09)
  IN1 w0.071: v4(39.36,22.71) 39.2,22.71 39.03,22.55 39.03,22.36 39.24,22.16 39.82,22.16 41.54,23.89 41.54,26.56 45.95,30.96 48.49,30.96 49.34,30.11 51.02,30.11 51.57,29.57 55.09,29.57 56.24,30.72 65.85,30.72 68.98,33.85 70.27,33.85 70.9,33.21 74.84,33.21 74.95,33.11 75.35,32.71 77.27,32.71 77.85,33.28 78.5,33.28 81.77,36.55 81.77,36.77 81.77,37.35 88.25,43.84 90.92,43.84 91.41,44.33 91.41,45.7 92.97,47.26 92.97,51.44 98.08,56.55 101.29,56.55 101.98,57.23 104.35,57.23 105.03,56.56 115.82,56.56 119.12,53.25 119.12,50.49 120.79,48.81
  BOTTOM w0.117: C316.1 35.26,21.44 37.51,21.44 37.94,21.87 38.81,21.87 39.19,22.26 39.19,22.54 v4(39.36,22.71)
EDP_TXP0_C: length 21.2
  BOTTOM w0.117: CN9.6 18.55,14.46 18.45,14.56 18.45,15.93 24.53,22 29.14,22 29.35,21.79 34.36,21.79 34.46,21.68 34.46,21.42 C316.2
EDP_TXP1: length 114.6
  IN1 w0.06: 118.56,50.48 118.56,50.48 119.72,49.32 119.88,49.32 120.97,48.23 120.97,47.98 v1(121.13,47.81)
  IN1 w0.071: v4(39.54,20.9) 39.84,20.9 39.95,21.01 39.95,21.37 43.63,25.05 43.63,27.97 46.14,30.49 48.29,30.49 49.14,29.64 50.83,29.64 51.37,29.09 55.29,29.09 56.44,30.24 66.08,30.24 69.15,33.31 70.12,33.31 70.69,32.74 74.65,32.74 75.15,32.23 77.47,32.23 78.05,32.81 78.7,32.81 82.25,36.36 82.25,37.15 88.46,43.36 91.12,43.36 91.89,44.13 91.89,45.5 93.45,47.06 93.45,51.19 98.33,56.07 103.4,56.07 103.41,56.07 115.56,56.07 118.56,53.08 118.56,50.48
  BOTTOM w0.117: C307.1 37.31,22.86 37.53,22.86 37.84,23.17 39.59,23.17 40.08,22.67 40.08,21.08 39.9,20.9 v4(39.54,20.9)
EDP_TXP1_C: length 24.9
  BOTTOM w0.117: CN9.3 17.05,14.44 16.96,14.53 16.96,15.91 24.07,23.02 36.28,23.02 36.36,22.94 36.36,22.68 C307.2
EMMC_COMP: length 6.7
  TOP w0.305: R74.1 105.93,41.67 106.5,41.1 106.5,39.33 106.89,38.93 106.89,37.94 107.82,37.02 U3.BC1
EN5VSW: length 3.9
  TOP w0.064: 66.24,45.97 66.75,45.97 PU5.M5
  TOP w0.102: 65.55,45.99 65.98,45.99 66.01,45.97 66.24,45.97
  TOP w0.117: 65.55,45.99 65.25,45.99 v2(64.97,46.27)
  GND1 w0.127: v9(64.64,46.51) 64.72,46.51 v2(64.97,46.27)
  GND2 w0.127: v9(64.64,46.51) 64.77,46.64 65.09,46.64 v8(65.09,46.65)
  BOTTOM w0.117: PR110.2 65.2,46.54 v8(65.09,46.65)
ENVR1: length 3.7
  TOP w0.064: PU5.M12 67.26,42.49 67.26,42
  TOP w0.102: 67.26,42 67.26,41.88 67.38,41.75 v2(67.51,41.75)
  GND1 w0.102: v9(67.18,41.75) v2(67.51,41.75)
  GND2 w0.127: v9(67.18,41.75) 67.18,41.73 66.97,41.52 v8(66.93,41.52)
  BOTTOM w0.117: v8(66.93,41.52) 66.73,41.72 PR143.1 PR142.1
ENVR2: length 5
  TOP w0.064: PU5.F11 70.01,43.23 69.77,42.99 69.77,41.85 69.64,41.72
  TOP w0.117: 69.64,41.72 69.64,41.49 v2(69.46,41.32)
  GND1 w0.127: v2(69.46,41.32) v9(69.08,40.93)
  GND2 w0.127: v8(68.7,40.81) 68.95,40.81 v9(69.08,40.93)
  BOTTOM w0.117: PR146.1 68.11,40.45 PR152.1 PR153.1 68.85,40.66 v8(68.7,40.81)
ENVR3: length 1.2
  TOP w0.152: PU5.E9 v2(70.75,44)
  GND1 w0.152: v2(70.75,44) 70.75,44.32 v9(70.65,44.42)
  GND2 w0.127: v8(70.71,44.03) 70.65,44.09 v9(70.65,44.42)
ENVR4: length 4.1
  TOP w0.076: PU5.C2 71.75,47.96 71.75,48.48
  TOP w0.14: 71.75,48.48 71.75,48.75 71.51,48.99 71.51,50.01 v4(70.92,50.6) 70.5,51.02 PR14.2
ENVR5: length 4.3
  TOP w0.102: v2(66.24,48.48) 66.29,48.53 66.55,48.53 66.76,48.33 66.76,47.99 PU5.M2
  GND1 w0.102: v9(65.91,48.48) v2(66.24,48.48)
  GND2 w0.127: v8(65.4,48.48) 65.4,48.48 v9(65.91,48.48)
  BOTTOM w0.117: PR340.2 64.69,47.86 64.62,47.86 64.46,48.02 PR96.2 64.46,48.32 64.62,48.48 v8(65.4,48.48)
ESPI_RST#: length 1.7
  GND1 w0.127: v9(109.24,35.35) 109.55,35.66 v2(109.64,35.66)
  GND2 w0.127: v9(109.24,35.35) 109.45,35.35 v8(109.64,35.15)
  BOTTOM w0.117: T54.1 109.34,34.85 v8(109.64,35.15)
FB_GT: length 6.2
  BOTTOM w0.203: PR252.1 PC182.1 170.66,20.99 PR253.2 171.43,21 PC183.2 172.38,21 v4(173.07,21.68) 173.08,21.69 173.31,21.69 173.73,22.11 173.92,22.11 174.67,22.86 PU12.3
FBLDO1: length 6.3
  GND1 w0.127: v2(71.02,44.73) 71.52,44.73 v9(71.7,44.54)
  IN2 w0.203: v9(71.7,44.54) 72.18,44.54 72.61,44.97 v9(75.89,44.97)
  GND2 w0.254: v9(75.89,44.97) 75.89,44.97 v8(75.89,44.57)
  BOTTOM w0.117: v4(75.51,45.19) 75.89,44.81 v8(75.89,44.57)
FBVR1N: length 24.9
  TOP w0.254: v3(68.76,44.47) PU5.J9
  IN2 w0.203: v4(53.89,32.2) 54.52,32.82 61,32.82 62.91,34.73 64.61,34.73 65.68,35.8 65.68,38.16 68.51,40.99 68.51,41.6 68.45,41.66 68.45,43.23 68.76,43.54 v3(68.76,44.47)
  BOTTOM w0.203: PR174.1 53.89,33.15 53.69,32.95 53.69,32.4 v4(53.89,32.2)
FBVR1P: length 25.4
  TOP w0.254: v3(68.25,43.96) PU5.K10
  IN2 w0.203: v4(53.21,32.22) 54.08,33.09 60.88,33.09 62.78,35 64.42,35 65.41,35.99 65.41,38.27 68.24,41.1 68.24,41.49 68.18,41.55 68.18,43.34 68.25,43.41 v3(68.25,43.96)
  BOTTOM w0.203: PR172.1 53.69,33.83 53.21,33.35 v4(53.21,33.33) v4(53.21,32.22)
FBVR2N: length 13.9
  TOP w0.254: v3(70.27,43.96) 70.5,43.73 PU5.E10
  IN2 w0.203: v4(72.16,35.73) 71.69,36.19 71.31,36.19 71.11,36.39 71.11,38.98 69.74,40.35 69.74,42.09 70.37,42.73 70.37,43.86 v3(70.27,43.96)
  BOTTOM w0.203: PR175.1 70.53,32.93 72.03,34.44 72.03,35.6 v4(72.16,35.73)
FBVR2P: length 12.4
  IN2 w0.203: v3(69.52,43.73) 69.58,43.67 69.58,43.58 69.89,43.26 69.89,42.63 69.47,42.21 69.47,42.09 69.46,42.07 69.46,40.26 70.84,38.88 70.84,36.29 71.4,35.73 v4(71.52,35.73)
  BOTTOM w0.203: PR173.1 70.35,33.59 70.76,33.59 71.62,34.46 71.62,35.63 v4(71.52,35.73)
FBVR3N: length 32.7
  TOP w0.203: PU5.D7 71.04,45.23 v3(71.27,45)
  IN2 w0.203: v3(71.27,45) 71.27,44.49 70.74,43.96 70.74,43.96 70.71,43.93 70.71,43.43 70.64,43.35 70.64,42.56 70.25,42.17 70.25,41.26 70.68,40.83 70.68,39.8 71.75,38.72 74.66,38.72 74.92,38.46 78.96,38.46 v4(80.26,39.77)
  BOTTOM w0.203: v4(80.26,39.77) 80.26,39.87 81.05,40.65 84.76,40.65 85.48,41.37 85.48,43.93 84.68,44.73 84.68,49.76 85.49,50.57 PR73.1
FBVR3P: length 30.7
  IN2 w0.203: v4(80.87,39.82) 80.8,39.82 80.43,40.19 80.08,40.19 79.75,39.86 79.75,39.64 78.84,38.73 75.04,38.73 74.76,39 71.85,39 70.95,39.91 70.95,40.94 70.53,41.36 70.53,42.07 70.91,42.45 70.91,43.08 71.52,43.69 v3(71.52,43.73)
  BOTTOM w0.203: v4(80.87,39.82) 80.87,40.02 81.24,40.39 84.95,40.39 85.75,41.18 85.75,44.04 84.94,44.84 84.94,49.61 85.21,49.88 PR75.1
FBVR4N: length 16.5
  IN2 w0.094: 73.53,46.78 72.76,46.78 72.26,47.28 71.39,47.28 71.07,46.96 71.07,46.2 v3(71.04,46.18)
  IN2 w0.203: v4(78.96,49.6) 78.9,49.6 78.63,49.32 77.15,49.32 76.64,48.81 76.64,47.19 76.16,46.71 73.6,46.71 73.53,46.78
  BOTTOM w0.203: v4(78.96,49.6) 78.76,49.8 78.76,52.09 79.5,52.82 79.5,54.07 PR61.1
FBVR4P: length 19.8
  TOP w0.06: PU5.C3 71.57,47.23 v3(71.79,47.02)
  IN2 w0.094: v3(70.02,44.23) 70.53,44.74 70.86,44.74 70.99,44.87 70.99,45.71 71.32,46.04 71.32,46.25 71.24,46.33 71.24,46.73 71.53,47.02 v3(71.79,47.02) 72.27,47.02 72.68,46.6 73.27,46.6 73.37,46.5
  IN2 w0.203: 73.37,46.5 73.43,46.44 76.27,46.44 76.91,47.07 76.91,48.7 77.26,49.05 78.77,49.05 v4(78.86,48.96)
  BOTTOM w0.203: PR60.1 79.19,53.92 79.19,52.9 78.49,52.2 78.49,49.33 v4(78.86,48.96)
FBVR5N: length 30.6
  TOP w0.203: PR2.2 v4(45.16,58.38)
  IN2 w0.203: v4(45.16,58.38) 55.16,58.38 58.08,55.46 58.08,52.82 59.28,51.62 62.68,51.62 64.05,50.25 64.76,50.25 65.5,49.51 65.5,47.48 66.47,46.51 66.85,46.51 66.97,46.62 v3(67.52,46.62)
FBVR5P: length 33
  TOP w0.203: v4(45.14,57.74) 45.34,57.54 PR4.1
  IN2 w0.203: v3(69.52,46.73) 69.49,46.7 68.25,46.7 68.12,46.57 67.94,46.57 67.65,46.28 67.01,46.28 66.96,46.24 66.29,46.24 65.21,47.32 65.21,49.42 64.65,49.98 63.94,49.98 62.6,51.32 59.1,51.32 57.7,52.71 57.7,55.46 55.28,57.88 45.28,57.88 v4(45.14,57.74)
FLASH_TRIG: length 1.8
  GND1 w0.127: v9(109.37,46.75) 109.24,46.63 109.24,46.62 109.05,46.43 v2(109.05,46.36)
  GND2 w0.127: v8(109.54,47.31) 109.54,46.94 109.37,46.76 v9(109.37,46.75)
  BOTTOM w0.117: v8(109.54,47.31) 109.93,46.92 T41.1
GPG6: length 3.4
  BOTTOM w0.117: U20.E2 151.82,4.54 151.82,3.86 153.3,2.38 T70.1
GPIOG2: length 24.2
  BOTTOM w0.117: R500.1 R499.2 168.12,11.62 167.13,10.62 v4(167.13,9.76) 167.13,9.63 166.64,9.15 165.09,9.15 164.15,8.21 164.15,4.38 161.87,2.09 154.88,2.09 153.06,3.91 U20.C1
H_PROCHOT#: length 261.3
  IN3 w0.094: v8(119.6,52.62) 119.82,52.83 119.89,52.83 125.59,58.53 158.57,58.53 166.48,50.62 175.17,50.62 176.3,51.75 185.28,51.75 186.57,50.46 187.17,50.46 187.8,49.82 190.31,49.82 192.99,47.14 192.99,34.65 193.67,33.97 193.67,30.03 193.14,29.5 190.14,29.5 186.79,26.14 186.79,21.05 186.68,20.94 v4(186.68,20.33) ; v4(65.88,16.17) 65.88,16.63 65.5,17.01 65.5,18.02 63.38,20.15 60.47,20.15 59,21.62 59,22.77 58.39,23.38 55.33,23.38 v7(55.14,23.18)
  IN4 w0.071: v4(65.88,16.17) 65.48,15.77 65.06,15.77 64.49,16.34 63.9,16.34 62.35,17.89 61.08,17.89 60.83,18.14 60.83,18.74 63.52,21.43 v8(63.52,21.68) ; v7(55.14,23.18) 55.14,24.94 56.24,26.05 56.69,26.05 62.05,31.4 63.12,31.4 63.62,31.9 64.74,31.9 65.68,32.84 65.68,33.49 66.29,34.1 66.29,35.54 66.11,35.72 66.11,37.99 65.68,38.42 65.68,42.75 65.07,43.36 65.07,46.04 65.37,46.35 65.37,47.08 64.92,47.54 64.92,48.38 65.37,48.83 66.37,48.83 66.95,49.41 66.95,49.54 v8(67.43,50.02) 68.02,50.61 69.24,50.61 69.63,51 70.06,51 70.28,51.21 70.28,52.28 69.73,52.83 69.73,58.71 70.56,59.54 79.4,59.54 80.02,58.92 81.05,58.92 81.67,59.54 85.21,59.54 85.67,59.09 88.26,59.09 88.49,58.86 89.07,58.86 89.76,58.17 89.76,55.4 91.18,53.98 93.92,53.98 95.75,55.81 95.75,57 96.74,57.99 106.15,57.99 106.85,57.28 113.43,57.28 113.58,57.44 115.5,57.44 119.6,53.33 v8(119.6,52.62)
  BOTTOM w0.117: v8(119.6,52.62) 119.73,52.49 v4(120.14,52.49) R161.2 121.1,51.3 R168.1 ; PR265.1 186.85,19.59 186.84,19.6 PR268.2 186.55,20.2 v4(186.68,20.33) ; PU14.10 v8(63.52,21.68) ; Q31.3 64.2,9.99 v4(63.77,10.42) 63.09,11.09 C413.1 63.09,11.6 64.29,12.8 64.29,14.89 64.51,15.1 65.04,15.1 65.88,15.94 v4(65.88,16.17) ; v8(67.43,50.02) 67.32,49.91 67.32,49.53 67.59,49.26 PR87.2
