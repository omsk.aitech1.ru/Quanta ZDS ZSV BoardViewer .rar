# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M1_A_A0: length 33.5
  IN1 w0.06: 115.24,29.89 115.24,29.94 116.12,30.82 116.12,31.28 116.77,31.94 116.77,34.48 116.76,34.5 116.76,34.66 116.83,34.74 116.83,34.91 116.63,35.11 v11(116.63,35.32)
  IN1 w0.089: v13(119.94,12.55) 112.97,12.55 112.88,12.64 112.88,26.08 115.24,28.44 115.24,29.89
  BOTTOM w0.147: v13(119.94,12.55) 119.94,12.98 120.14,13.18 U5A1.R2
M1_A_A1: length 33.9
  IN1 w0.06: v11(116.96,34.58) 116.89,34.52 116.89,31.88 116.26,31.25 116.26,30.78 115.47,29.99 115.47,29.89
  IN1 w0.089: 115.47,29.89 115.47,28.27 113.2,26 113.2,14.06 113.53,13.73 113.53,13.12 113.64,13.01 113.85,13.01 113.96,13.12 113.96,13.33 114.07,13.44 114.26,13.44 114.37,13.33 114.37,13.1 114.48,12.99 114.69,12.99 114.8,13.1 114.8,13.33 114.91,13.44 115.1,13.44 115.21,13.33 115.21,13.1 115.32,12.99 115.51,12.99 115.61,13.1 115.61,13.33 115.72,13.44 115.91,13.44 116.02,13.33 116.02,13.05 116.13,12.94 120.06,12.94 120.11,12.89 v13(120.52,12.89)
  BOTTOM w0.147: v13(120.52,12.89) 120.52,13.32 120.61,13.41 120.61,14.31 U5A1.P2
M1_A_A2: length 34
  IN1 w0.06: v11(117.28,34.83) 117.28,34.83 117.28,34.71 117.28,34.71 117.28,34.41 117.28,34.4 117.28,34.4 117.13,34.26 117.13,31.78 116.58,31.23 116.58,30.74 115.93,30.09 115.93,29.89
  IN1 w0.089: v13(121.2,13.47) 121.11,13.56 116.81,13.56 116.29,14.08 114.07,14.08 113.96,14.18 113.96,14.38 114.07,14.49 114.44,14.49 114.55,14.59 114.55,14.76 114.44,14.87 113.94,14.87 113.84,14.97 113.84,15.14 113.95,15.25 114.43,15.25 114.54,15.36 114.54,15.52 114.43,15.63 113.96,15.63 113.86,15.73 113.86,15.88 113.96,15.98 114.43,15.98 114.54,16.09 114.54,16.25 114.43,16.36 114.05,16.36 113.82,16.58 113.82,25.74 115.93,27.84 115.93,29.89
  BOTTOM w0.102: U5A1.N2 121.44,14.14 121.2,13.9 v13(121.2,13.47)
M1_A_A3: length 33.8
  IN1 w0.06: 119.2,30.49 119.07,30.61 119.07,33.36 118.78,33.64 118.78,34.1 119.09,34.4 119.09,34.66 119.03,34.72 119.03,34.86 118.89,35 v11(118.89,35.07)
  IN1 w0.089: 119.2,30.49 119.53,30.15 119.53,25.72 118.08,24.27 118.08,21.67 118.23,21.52 118.23,20.82 118.76,20.29 118.76,19.44 118.87,19.33 119.48,19.33 119.58,19.24 119.58,19.1 119.48,19.01 118.91,19.01 118.82,18.91 118.82,18.77 118.91,18.68 120.12,18.68 120.21,18.58 120.21,18.45 120.12,18.35 118.89,18.35 118.79,18.25 118.79,18.12 118.89,18.02 123.79,18.02 123.9,18.12 123.9,18.35 123.79,18.45 v13(121.13,18.45)
  BOTTOM w0.102: v13(121.13,18.45) 121.13,15.61 U5A1.N3
M1_A_A4: length 34.5
  IN1 w0.06: 115.7,29.89 115.7,30.04 116.41,30.75 116.41,31.24 117.01,31.83 117.01,34.3 117.16,34.45 117.16,34.66 117.08,34.74 117.08,34.91 117.16,34.99 117.16,35.16 117.08,35.24 117.08,35.4 117.16,35.48 117.16,35.65 117.02,35.78 117.02,35.99 v11(116.96,36.06)
  IN1 w0.089: v13(121.74,13.27) 121.5,13.27 121.35,13.12 121.06,13.12 120.92,13.25 116.68,13.25 116.16,13.77 113.94,13.77 113.51,14.19 113.51,25.87 115.7,28.06 115.7,29.89
  BOTTOM w0.102: v13(121.74,13.27) 121.74,14.93 121.89,15.08 121.89,15.1 U5A1.M3
M1_A_A5: length 33.9
  IN1 w0.06: 119.04,30.33 118.94,30.44 118.94,33.31 118.66,33.59 118.66,34.15 118.89,34.38 v11(118.89,34.58)
  IN1 w0.089: v13(126.37,15.71) 126.37,16.09 126.64,16.36 126.64,18.27 126.41,18.5 124.33,18.5 124.23,18.4 124.23,18.19 124.33,18.09 126.05,18.09 126.16,17.99 126.16,17.81 126.05,17.71 118.56,17.71 118.45,17.82 118.45,20.16 117.82,20.78 117.82,24.46 119.22,25.85 119.22,30.16 119.04,30.33
  BOTTOM w0.102: U5A1.F3 125.99,15.34 v13(126.37,15.71)
M1_A_A6: length 32.7
  IN1 w0.06: 118.9,30.04 118.9,30.25 118.82,30.33 118.82,33.24 118.54,33.51 118.54,34.22 118.69,34.36 118.69,34.66 118.77,34.74 118.77,34.91 118.69,34.99 118.69,35.16 118.89,35.36 v11(118.89,35.57)
  IN1 w0.089: 118.9,30.04 118.9,25.98 117.51,24.59 117.51,20.66 118.06,20.1 118.06,17 118.16,16.9 125.67,16.9 125.94,16.63 125.94,15.65 126.22,15.37 126.51,15.37 126.55,15.41 127.88,15.41 127.98,15.3 127.98,15.06 127.88,14.96 v13(126.98,14.96)
  BOTTOM w0.102: U5A1.E3 v13(126.98,14.96)
M1_A_A7: length 33
  IN1 w0.06: 117.37,30.06 117.37,30.29 117.56,30.48 117.56,31.34 118.05,31.83 118.05,34.44 118.04,34.45 118.04,34.66 118.16,34.78 118.16,34.87 118.04,34.99 118.04,35.16 118.24,35.36 v11(118.24,35.57)
  IN1 w0.089: 117.37,30.06 117.37,26.61 115.96,25.2 115.96,19.89 116.38,19.47 116.38,14.9 117.1,14.19 121.88,14.19 122.36,13.71 125.93,13.71 v4(126.32,14.1)
  BOTTOM w0.102: v4(126.32,14.1) 126.64,14.42 U5A1.E2
M1_A_A8: length 33.5
  IN1 w0.06: v11(117.92,34.83) 117.92,34.82 117.92,34.4 117.93,34.39 117.93,31.89 117.11,31.07 117.11,30.23 117.05,30.17 117.05,29.89
  IN1 w0.089: v13(126.96,14.05) 126.31,13.4 122.16,13.4 121.69,13.88 116.97,13.88 116.07,14.77 116.07,19.34 115.65,19.76 115.65,25.33 117.05,26.73 117.05,29.89
  BOTTOM w0.102: U5A1.D2 126.96,14.16 v13(126.96,14.05)
M1_A_A9: length 33.6
  IN1 w0.06: v11(118.24,34.58) 118.17,34.51 118.17,31.78 117.7,31.31 117.7,30.43 117.68,30.42 117.68,30.22
  IN1 w0.089: v4(127.64,14.05) 128.03,14.05 128.14,14.16 128.14,14.38 128.02,14.5 123.3,14.5 123.23,14.57 122.31,14.57 122.24,14.5 117.23,14.5 116.69,15.03 116.69,19.6 116.28,20.02 116.28,25.07 117.68,26.48 117.68,30.22
  BOTTOM w0.102: v4(127.64,14.05) 127.94,14.35 U5A1.C2
M1_A_CLKN0: length 36.1
  IN1 w0.06: v11(118.57,35.32) 118.57,35.11 118.36,34.91 118.36,34.74 118.44,34.66 118.44,34.5 118.3,34.36 118.3,33.26 118.56,33 118.56,32.62 118.41,32.47 118.41,32.06 118.56,31.91 118.56,31.56 118.42,31.43 118.01,31.43 117.88,31.3 117.88,31.1 118.01,30.97 118.5,30.97 118.56,30.91 118.56,30.8 118.5,30.74 118.35,30.74 118.22,30.61 118.22,30.44 118.2,30.43
  IN1 w0.089: v13(124.38,14.89) 124.17,15.09 123.8,15.09 123.6,15.3 123.6,16.09 123.49,16.19 122.16,16.19 122.06,16.09 122.06,15.28 121.85,15.07 121.34,15.07 121.13,15.28 121.13,16.09 121.03,16.19 120.08,16.19 119.93,16.05 119.93,15.27 119.72,15.06 118.87,15.06 118.66,15.27 118.66,16.09 118.56,16.19 118.21,16.19 118.1,16.09 118.1,15.25 117.89,15.04 117.42,15.04 117.21,15.25 117.21,19.84 116.81,20.24 116.81,24.88 118.2,26.27 118.2,30.43
  BOTTOM w0.102: v13(124.38,14.89) 124.37,14.88 124.37,14.82 U5A1.J2
M1_A_CLKN1: length 35
  IN2 w0.06: 116.43,30.97 116.43,30.98 116.43,30.99 116.46,31.02 116.46,31.34 116.87,31.75 116.87,35.59 116.97,35.69 116.97,36.49 v14(117.28,36.8)
  IN2 w0.109: v13(106.61,14.94) 106.67,15.01 106.67,15.22 106.55,15.35 106.04,15.35 105.94,15.25 105.94,14.64 106.04,14.54 110.88,14.54 110.98,14.64 110.98,14.84 111.19,15.05 111.75,15.05 111.96,14.84 111.96,14.61 112.03,14.54 112.44,14.54 113.33,15.44 113.33,16.15 113.24,16.24 112.79,16.24 112.58,16.45 112.58,16.9 112.79,17.11 113.25,17.11 113.36,17.22 113.36,19.74 114.16,20.53 114.16,25.21 116.43,27.47 116.43,30.97
  BOTTOM w0.102: v13(106.61,14.94) 106.61,14.9 106.27,14.57 U4A1.J2
M1_A_CLKP0: length 36.1
  IN1 w0.06: 118.38,30.42 118.34,30.46 118.34,30.56 118.4,30.62 118.55,30.62 118.68,30.75 118.68,30.96 118.55,31.09 118.06,31.09 118,31.15 118,31.25 118.06,31.31 118.47,31.31 118.68,31.51 118.68,31.96 118.53,32.11 118.53,32.42 118.68,32.57 118.68,33.05 118.42,33.31 118.42,34.31 118.56,34.45 118.56,34.59 118.57,34.6 v11(118.57,34.83)
  IN1 w0.089: v13(124.4,15.7) 124.56,15.7 124.66,15.6 124.66,15.37 124.56,15.27 123.88,15.27 123.78,15.37 123.78,16.16 123.57,16.37 122.09,16.37 121.88,16.16 121.88,15.35 121.78,15.25 121.41,15.25 121.31,15.35 121.31,16.16 121.1,16.37 120.01,16.37 119.75,16.12 119.75,15.35 119.65,15.24 118.95,15.24 118.84,15.35 118.84,16.16 118.63,16.36 118.13,16.36 117.93,16.16 117.93,15.32 117.82,15.21 117.49,15.21 117.39,15.32 117.39,19.91 116.99,20.31 116.99,24.8 118.38,26.2 118.38,30.42
  BOTTOM w0.102: v13(124.4,15.7) 124.39,15.69 124.39,15.47 124.22,15.29 U5A1.J3
M1_A_CLKP1: length 35
  IN2 w0.06: 116.61,30.97 116.61,30.99 116.58,31.02 116.58,31.29 116.99,31.7 116.99,35.54 117.09,35.64 117.09,36.11 v14(117.28,36.3)
  IN2 w0.109: 116.61,30.97 116.61,27.39 114.35,25.13 114.35,20.46 113.55,19.66 113.55,17.14 113.33,16.92 112.87,16.92 112.77,16.82 112.77,16.53 112.87,16.43 113.32,16.43 113.52,16.22 113.52,15.36 112.51,14.36 111.96,14.36 111.78,14.54 111.78,14.76 111.68,14.87 111.27,14.87 111.17,14.76 111.17,14.56 110.96,14.35 105.96,14.35 105.75,14.56 105.75,15.32 105.96,15.53 106.44,15.53 v13(106.63,15.73)
  BOTTOM w0.102: v13(106.63,15.73) 106.63,15.66 U4A1.J3
M1_A_DQ0: length 17.5
  IN2 w0.06: 119.86,31.38 119.5,31.73 119.5,35.09 119.57,35.16 119.57,35.82 119.73,35.98 119.73,36.14 119.65,36.22 119.65,36.39 119.73,36.47 119.73,36.63 119.65,36.71 119.65,36.88 119.77,37 119.94,37 120.1,36.84 120.24,36.84 120.31,36.91 120.31,36.99 120.26,37.04 v14(120.18,37.04)
  IN2 w0.109: 119.86,31.38 121.56,29.67 121.56,23.75 121.57,23.74 121.57,22.62 121.59,22.6 121.59,22.28 v13(121.78,22.09)
  BOTTOM w0.147: v13(121.78,22.09) 121.78,22 U5A1.M11
M1_A_DQ1: length 19.2
  IN2 w0.06: 119.14,30.85 119.14,35.24 119.21,35.31 119.21,36.9 119.35,37.04 v14(119.53,37.04)
  IN2 w0.109: 119.14,30.85 120.64,29.34 120.64,25.1 120.2,24.66 120.2,23.27 120.28,23.2 120.28,22.73 120.07,22.52 120.07,21.89 120.16,21.8 120.7,21.8 120.77,21.73 120.77,21.04 120.88,20.94 121.07,20.94 121.14,20.87 v13(121.14,20.53)
  BOTTOM w0.147: U5A1.P9 120.79,20.18 v13(121.14,20.53)
M1_A_DQ2: length 18.4
  IN2 w0.06: 120.52,31.78 120.52,34.47 120.06,34.92 120.06,35.78 120.09,35.82 120.09,35.98 v14(120.18,36.06)
  IN2 w0.109: v13(121.79,20.51) 122.17,20.89 122.6,20.89 123.11,21.39 123.11,24.65 123.39,24.92 123.39,28.91 120.52,31.78
  BOTTOM w0.147: U5A1.N10 121.44,20.85 v13(121.79,20.51)
M1_A_DQ3: length 17.1
  IN2 w0.06: v14(119.53,36.55) 119.53,36.54 119.33,36.34 119.33,35.26 119.26,35.19 119.26,30.99 119.4,30.84
  IN2 w0.109: 119.4,30.84 120.94,29.31 120.94,24.98 120.49,24.54 120.49,24.37 120.57,24.29 120.86,24.29 120.95,24.2 120.95,24.07 120.86,23.98 120.62,23.98 120.49,23.86 120.49,23.39 120.53,23.36 120.57,23.32 120.57,22.56 120.64,22.49 120.97,22.49 121.08,22.38 v13(121.08,22.1)
  BOTTOM w0.147: v13(121.08,22.1) 121.08,22.08 121.44,21.72 U5A1.N11
M1_A_DQ4: length 19.9
  IN2 w0.06: v14(120.5,36.3) 120.5,36.2 120.5,36.19 120.5,35.88 120.3,35.68 120.3,35.23 120.46,35.07 120.46,34.86 120.76,34.57 120.76,32.1 121.08,31.78 121.13,31.78
  IN2 w0.109: v13(121.79,19.75) 122.16,20.12 122.62,20.12 123.53,21.03 123.53,24.54 123.97,24.98 123.97,28.94 121.13,31.78
  BOTTOM w0.147: U5A1.N9 v13(121.79,19.75)
M1_A_DQ5: length 20.5
  IN2 w0.06: 121.28,31.96 121.08,31.96 120.88,32.16 120.88,34.62 120.58,34.91 120.58,35.12 120.42,35.28 120.42,35.63 120.7,35.91 120.7,36.39 120.5,36.59 v14(120.5,36.8)
  IN2 w0.109: 121.28,31.96 124.3,28.94 124.3,23.91 123.77,23.38 123.77,20.86 122.6,19.69 v13(122.4,19.69)
  BOTTOM w0.147: v13(122.4,19.69) 122.09,19.39 U5A1.M8
M1_A_DQ6: length 17.5
  IN2 w0.06: 119.68,31.27 119.38,31.57 119.38,35.14 119.45,35.21 119.45,35.98 v14(119.53,36.06)
  IN2 w0.109: 119.68,31.27 119.83,31.12 119.83,31.02 119.75,30.94 119.75,30.82 119.84,30.73 119.97,30.73 120.05,30.8 120.15,30.8 120.29,30.66 120.29,30.56 120.17,30.45 120.17,30.32 120.28,30.22 120.4,30.22 120.5,30.32 120.63,30.32 120.75,30.21 120.75,30.08 120.68,30.02 120.68,29.89 120.78,29.79 120.91,29.79 121.01,29.89 121.06,29.89 121.25,29.7 121.25,22.69 121.42,22.53 121.42,22.21 121.43,22.2 121.43,21.62 v13(121.74,21.3)
  BOTTOM w0.147: U5A1.M10 121.74,21.24 v13(121.74,21.3)
M1_A_DQ7: length 18.7
  IN2 w0.06: v14(120.18,36.55) 120.18,36.34 120.38,36.14 120.38,35.93 120.18,35.73 120.18,34.97 120.64,34.52 120.64,31.97 120.72,31.88
  IN2 w0.109: v13(122.49,20.48) 122.74,20.73 122.76,20.73 123.34,21.31 123.34,24.63 123.68,24.97 123.68,28.93 120.72,31.88
  BOTTOM w0.147: v13(122.49,20.48) 122.1,20.09 U5A1.M9
M1_A_DQ8: length 20.6
  IN2 w0.06: v14(120.82,37.04) 120.82,36.83 121.02,36.63 121.02,36.47 120.94,36.39 120.94,35.58 120.94,35.06 121.24,34.77 121.24,33.04 121.84,32.44 121.84,32.34
  IN2 w0.109: v13(126.37,21.28) 126.37,21.03 126.18,20.84 125.2,20.84 125.19,20.85 125.1,20.85 124.91,21.04 124.91,22.31 125.39,22.79 125.39,28.79 121.84,32.34
  BOTTOM w0.147: U5A1.F10 126.37,21.28 v13(126.37,21.28)
M1_A_DQ9: length 21.6
  IN2 w0.06: 122.37,33.87 122.24,34 122.24,35.12 122.33,35.21 122.33,35.69 122.11,35.91 122.11,36.44 121.79,36.76 v14(121.79,36.8)
  IN2 w0.109: 122.37,33.87 126.44,29.8 127.02,29.8 127.98,28.84 127.98,26.12 128.8,25.31 128.8,23.68 129.26,23.21 129.26,21.14 129.06,20.93 128.13,20.93 v13(127.67,20.48)
  BOTTOM w0.147: U5A1.D9 v13(127.67,20.48)
M1_A_DQ10: length 20.2
  GND1 w0.06: v14(120.74,35.5) v12(120.82,36.06)
  IN2 w0.06: v14(120.74,35.5) 120.74,35.3 120.82,35.22 120.82,35.01 121.12,34.72 121.12,32.99 121.69,32.42 121.69,32.16
  IN2 w0.109: 121.69,32.16 125.09,28.76 125.09,23.83 124.68,23.42 124.68,22.77 124.71,22.74 124.71,20.66 124.7,20.65 124.7,20.31 124.94,20.07 125.97,20.07 v13(126.37,20.48)
  BOTTOM w0.147: v13(126.37,20.48) 125.99,20.1 U5A1.F9
M1_A_DQ11: length 18.8
  IN2 w0.06: 121.76,33.41 121.76,34.78 121.31,35.23 121.31,35.91 v14(121.46,36.06)
  IN2 w0.109: v13(126.36,22.08) 126.13,22.08 126.07,22.14 126.07,22.42 126.21,22.56 126.61,22.56 126.87,22.82 126.87,23.4 126.99,23.53 127.55,23.53 127.63,23.6 127.63,24.82 127.17,25.28 126.92,25.28 126.79,25.41 126.79,28.38 121.76,33.41
  BOTTOM w0.147: v13(126.36,22.08) 126.36,22.08 125.99,21.71 U5A1.F11
M1_A_DQ12: length 21.3
  IN2 w0.06: v14(121.46,37.04) 121.46,36.83 121.79,36.5 121.87,36.5 121.99,36.39 121.99,35.86 122.21,35.64 122.21,35.26 122.12,35.17 122.12,33.87 122.26,33.73
  IN2 w0.109: 122.26,33.73 126.38,29.6 126.87,29.6 127.69,28.77 127.69,26 128.5,25.19 128.5,22.66 128.28,22.45 128.2,22.45 128,22.24 128,21.14 127.71,20.84 127.35,20.84 v13(126.98,20.48)
  BOTTOM w0.147: v13(126.98,20.48) 126.64,20.14 U5A1.E9
M1_A_DQ13: length 22.1
  IN2 w0.06: v14(120.82,36.55) 120.82,35.86 120.54,35.58 120.54,35.33 120.7,35.17 120.7,34.96 121,34.67 121,32.93 121.53,32.39 121.53,32.01
  IN2 w0.109: 121.53,32.01 124.8,28.75 124.8,23.97 123.96,23.13 123.96,20.31 124.17,20.1 124.45,20.1 124.75,19.8 124.75,19.56 124.95,19.35 126.05,19.35 v13(126.37,19.68)
  BOTTOM w0.147: v13(126.37,19.68) 125.99,19.3 U5A1.F8
M1_A_DQ14: length 19.6
  IN2 w0.06: v14(121.46,36.55) 121.46,36.34 121.66,36.14 121.66,35.98 121.44,35.75 121.44,35.26 121.88,34.83 121.88,33.57 121.98,33.47 ; v13(126.93,21.28) 126.7,21.52 126.7,22.33
  IN2 w0.109: 121.98,33.47 126.27,29.18 126.47,29.18 127.1,28.56 127.1,25.77 127.92,24.94 127.92,23.62 127.6,23.3 127.17,23.3 127.07,23.2 127.07,22.74 126.7,22.37 126.7,22.33
  BOTTOM w0.147: U5A1.E10 126.93,21.19 v13(126.93,21.28)
M1_A_DQ15: length 19
  IN2 w0.06: 122.08,33.62 122,33.71 122,34.88 121.56,35.31 121.56,35.7 121.85,35.99 121.85,36.24 v14(121.79,36.3)
  IN2 w0.109: 122.08,33.62 126.28,29.42 126.64,29.42 127.39,28.67 127.39,25.89 128.21,25.06 128.21,23.59 127.57,22.95 127.57,22.81 127.62,22.77 127.74,22.77 127.83,22.68 127.83,22.55 127.74,22.46 127.15,22.46 127.04,22.36 v13(127.04,22.08)
  BOTTOM w0.147: v13(127.04,22.08) 127.04,22.04 126.7,21.69 U5A1.E11
M1_A_DQ16: length 18.6
  IN1 w0.06: 114.37,29.93 114.37,30.08 116.11,31.82 116.11,33.37 116.33,33.59 116.33,34.49 v11(115.99,34.83)
  IN1 w0.089: 114.37,29.93 114.37,28.61 111.54,25.77 111.54,22.77 111.19,22.43 110.41,22.43 110.2,22.21 110.2,22.11 110.2,22.11 110.2,21.19 109.88,20.87 109.6,20.87 v13(109.21,20.48)
  BOTTOM w0.147: U4A1.E9 108.87,20.14 v13(109.21,20.48)
M1_A_DQ17: length 18
  TOP w0.06: U3.BN27 v11(115.67,34.11)
  IN1 w0.06: 115.65,32.1 115.73,32.18 115.73,33.48 115.67,33.55 v11(115.67,34.11)
  IN1 w0.089: 115.65,32.1 113.66,30.11 113.66,28.96 110.51,25.81 110.51,24.21 109.75,23.45 108.62,23.45 108.53,23.36 108.53,23.22 108.62,23.12 109.22,23.12 109.32,23.03 109.32,22.89 109.22,22.8 108.69,22.8 108.56,22.67 v13(108.56,22.09)
  BOTTOM w0.147: v13(108.56,22.09) 108.56,22.01 108.24,21.69 U4A1.F11
M1_A_DQ18: length 19
  IN1 w0.06: 114.6,29.93 114.6,30.14 116.43,31.97 116.43,32.78 116.53,32.89 116.53,34.34 116.49,34.39 116.49,34.61 115.99,35.11 v11(115.99,35.32)
  IN1 w0.089: 114.6,29.93 114.6,28.51 111.85,25.76 111.85,22.61 111.5,22.27 111.5,21.98 111.5,21.98 111.5,21.14 111.22,20.86 110.4,20.86 110.04,20.51 v13(109.82,20.51)
  BOTTOM w0.147: v13(109.82,20.51) 109.52,20.2 U4A1.D9
M1_A_DQ19: length 20.2
  IN1 w0.06: v11(115.02,35.07) 115.02,34.86 115.22,34.66 115.22,33.49 115.09,33.36 115.09,32.48
  IN1 w0.089: v13(108.52,21.28) 108.17,20.94 107.83,20.94 107.46,21.31 107.46,22.35 107.8,22.69 107.8,23.47 107.62,23.65 107.62,26.38 108.62,27.38 110.47,27.38 112.41,29.32 112.41,29.8 115.09,32.48
  BOTTOM w0.147: U4A1.F10 108.22,20.98 108.52,21.28 v13(108.52,21.28)
M1_A_DQ20: length 20.2
  IN1 w0.06: 114.94,32.63 114.94,33.5 115.02,33.58 v11(115.02,34.58)
  IN1 w0.089: 114.94,32.63 112.16,29.85 112.16,29.51 110.34,27.69 108.49,27.69 107.31,26.51 107.31,24.01 106.96,23.66 106.96,22.63 107.22,22.36 107.22,21.17 107.67,20.73 108.36,20.73 v13(108.6,20.48)
  BOTTOM w0.147: v13(108.6,20.48) 108.22,20.1 U4A1.F9
M1_A_DQ21: length 18.2
  IN1 w0.06: 115.79,31.96 115.87,32.03 115.87,33.54 116.07,33.74 116.07,33.84 116.02,33.89 115.93,33.89 115.87,33.95 115.87,34.07 115.92,34.12 116,34.12 116.06,34.18 116.06,34.25 116,34.31 115.67,34.31 115.61,34.37 115.61,34.43 115.67,34.49 115.72,34.49 115.76,34.54 115.76,34.6 115.67,34.7 v11(115.67,35.07)
  IN1 w0.089: 115.79,31.96 113.91,30.08 113.91,28.84 110.85,25.77 110.85,24.11 109.17,22.43 109.12,22.43 108.9,22.21 108.9,21.62 v13(109.23,21.3)
  BOTTOM w0.147: U4A1.E10 109.23,21.25 v13(109.23,21.3)
M1_A_DQ22: length 22.4
  IN1 w0.06: 114.75,32.76 114.82,32.83 114.82,34.66 114.9,34.74 114.9,34.91 114.82,34.99 114.82,35.16 115.02,35.36 v11(115.02,35.57)
  IN1 w0.089: 114.75,32.76 111.88,29.89 111.88,29.67 110.21,28 108.36,28 106.99,26.64 106.99,23.94 106.78,23.73 106.78,22.56 107.02,22.33 107.02,20.73 106.92,20.64 106.92,20.32 107.1,20.14 108.15,20.14 v13(108.6,19.68)
  BOTTOM w0.147: U4A1.F8 108.22,19.3 v13(108.6,19.68)
M1_A_DQ23: length 18.7
  IN1 w0.06: v11(115.67,35.57) 115.79,35.44 115.79,35.24 115.87,35.16 115.87,34.99 115.79,34.91 115.79,34.75 115.79,34.75 115.79,34.74 116.21,34.33 116.21,33.64 115.99,33.42 115.99,31.88 114.14,30.03
  IN1 w0.089: v13(109.27,22.08) 109.93,22.74 110.43,22.74 110.54,22.85 110.54,23.33 110.64,23.43 110.77,23.43 110.87,23.33 110.87,23 110.98,22.89 111.09,22.89 111.2,23 111.2,25.76 114.14,28.71 114.14,30.03
  BOTTOM w0.147: U4A1.E11 108.92,21.69 109.27,22.04 v13(109.27,22.08)
M1_A_DQ24: length 22.1
  IN1 w0.06: 114.64,32.98 114.7,33.04 114.7,34.82 v11(114.7,34.83)
  IN1 w0.089: 114.64,32.98 110.84,29.18 110.66,29.18 109.93,28.45 108.07,28.45 106.29,26.66 106.29,24.35 106.15,24.21 106.15,23.88 106.26,23.77 106.26,20.88 104.96,19.58 104.42,19.58 104.33,19.67 v13(103.98,19.67)
  BOTTOM w0.147: U4A1.M8 103.98,19.64 v13(103.98,19.67)
M1_A_DQ25: length 23.9
  IN1 w0.06: 114.49,33.14 114.58,33.23 114.58,34.17 114.5,34.25 114.5,34.91 114.61,35.02 114.61,35.23 v11(114.7,35.32)
  IN1 w0.089: v13(102.71,20.51) 103.16,20.06 104.15,20.06 104.36,19.84 104.92,19.84 106.05,20.97 106.05,23.7 105.98,23.77 105.98,26.79 107.94,28.76 109.8,28.76 110.52,29.48 110.83,29.48 114.49,33.14
  BOTTOM w0.147: v13(102.71,20.51) 103.02,20.19 U4A1.P9
M1_A_DQ26: length 20.9
  IN1 w0.089: v11(113.73,34.58) 113.73,34.47 110.44,31.17 109.55,31.17 109.11,30.73 106.84,30.73 102.57,26.47 102.57,26.35 102.7,26.22 102.83,26.22 102.94,26.11 102.94,25.97 102.83,25.86 102.66,25.86 102.57,25.78 102.57,24.24 102.93,23.88 103.52,23.88 103.83,23.58 103.83,22.59 103.96,22.46 v13(103.96,22.11)
  BOTTOM w0.147: U4A1.M11 104.32,21.72 104.01,22.04 104.01,22.07 v13(103.96,22.11)
M1_A_DQ27: length 22.8
  IN1 w0.06: v11(114.38,35.57) 114.02,35.57 113.86,35.4 113.86,35.24 113.93,35.16 113.93,34.99 113.86,34.91 113.86,34.74 113.93,34.67 113.93,34.44 113.4,33.9 113.4,33.8 113.28,33.68
  IN1 w0.089: 113.28,33.68 110.44,30.84 109.59,30.84 109.22,30.47 107.01,30.47 103.44,26.89 103.44,25.85 102.89,25.3 102.89,24.37 103.06,24.2 103.64,24.2 104.08,23.76 104.08,22.64 104.32,22.41 104.32,21.64 v13(103.98,21.31)
  BOTTOM w0.147: v13(103.98,21.31) 103.98,21.24 U4A1.M10
M1_A_DQ28: length 22.4
  IN1 w0.06: 114.26,33.53 114.26,33.89 114.18,33.97 114.18,34.17 114.38,34.37 v11(114.38,35.07)
  IN1 w0.089: v13(103.35,20.48) 103.72,20.85 105.35,20.85 105.63,21.14 105.63,23.63 105.35,23.91 105.35,27.05 107.68,29.38 109.54,29.38 110.12,29.96 110.69,29.96 114.26,33.53
  BOTTOM w0.147: U4A1.N9 103.67,20.15 v13(103.35,20.48)
M1_A_DQ29: length 21.6
  TOP w0.06: U3.BN23 v11(114.38,34.09)
  IN1 w0.06: 114.4,33.36 114.46,33.42 114.46,34.01 v11(114.38,34.09)
  IN1 w0.089: 114.4,33.36 110.77,29.73 110.32,29.73 109.67,29.07 107.81,29.07 105.67,26.92 105.67,23.84 105.82,23.68 105.82,21.07 104.85,20.1 104.39,20.1 v13(103.98,20.51)
  BOTTOM w0.147: U4A1.M9 104.32,20.16 v13(103.98,20.51)
M1_A_DQ30: length 22.6
  IN1 w0.089: v11(113.73,35.57) 113.35,35.18 113.35,34.53 113.18,34.37 113.14,34.37 110.51,31.73 109.35,31.73 108.88,31.27 106.49,31.27 101.95,26.73 101.95,22.89 102.38,22.47 102.38,21.95 102.67,21.65 103.02,21.65 v13(103.4,21.27)
  BOTTOM w0.147: v13(103.4,21.27) 103.4,21.22 103.67,20.95 U4A1.N10
M1_A_DQ31: length 20.7
  IN1 w0.089: v11(113.73,35.07) 113.51,34.84 113.51,34.48 110.51,31.48 109.47,31.48 109,31 106.66,31 102.26,26.6 102.26,24.11 102.81,23.56 102.81,22.69 v13(103.4,22.11)
  BOTTOM w0.147: v13(103.4,22.11) 103.4,21.97 U4A1.N11
M1_A_DQ32: length 17.5
  IN1 w0.06: 123.18,31.51 122.97,31.51 121.76,32.72 121.76,32.9 121.71,32.95 121.49,32.95 121.43,33.01 121.43,33.09 121.49,33.15 121.69,33.15 121.76,33.23 121.76,33.84 121.71,33.89 121.59,33.89 121.53,33.95 121.53,34.01 121.59,34.07 121.72,34.07 121.78,34.13 121.78,34.19 121.72,34.25 121.59,34.25 121.55,34.29 121.55,34.5 v11(121.46,34.58)
  IN1 w0.089: 123.18,31.51 126.05,28.64 126.05,26.91 129.28,23.68 129.28,22.64 128.98,22.34 128.98,22.14 v13(128.91,22.08)
  BOTTOM w0.147: v13(128.91,22.08) 128.89,22.05 128.89,21.99 U5A1.B11
M1_A_DQ33: length 19.3
  IN1 w0.06: v11(121.79,34.83) 122.03,34.58 122.03,32.81 123.01,31.84 123.47,31.84 123.54,31.77
  IN1 w0.089: 123.54,31.77 126.71,28.6 126.71,27.21 130.02,23.91 130.02,21.01 129.48,20.48 v13(128.91,20.48)
  BOTTOM w0.147: U5A1.B9 128.59,20.16 v13(128.91,20.48)
M1_A_DQ34: length 19.4
  IN1 w0.06: 121.02,32.02 120.94,32.1 120.94,33.92 121.02,34 121.02,34.17 120.82,34.37 v11(120.82,35.07)
  IN1 w0.089: v13(128.35,21.28) 127.93,20.86 126.26,20.86 126.01,21.11 126.01,22.28 125.81,22.49 125.81,23.62 125.41,24.01 125.41,24.24 124.4,25.25 124.4,28.63 121.02,32.02
  BOTTOM w0.147: U5A1.C10 127.96,20.89 128.32,21.25 128.32,21.26 v13(128.35,21.28)
M1_A_DQ35: length 20.8
  IN1 w0.06: 123.77,31.84 123.65,31.96 123.06,31.96 122.16,32.86 122.16,34.64 122.1,34.7 122.1,34.79 121.79,35.11 v11(121.79,35.32)
  IN1 w0.089: 123.77,31.84 127.04,28.57 127.04,27.34 130.35,24.04 130.35,20.9 129.42,19.97 129.2,19.97 v13(128.91,19.68)
  BOTTOM w0.147: v13(128.91,19.68) 128.59,19.36 U5A1.B8
M1_A_DQ36: length 19.9
  TOP w0.06: U3.BN43 v11(120.82,34.09)
  IN1 w0.06: 120.87,31.9 120.82,31.95 v11(120.82,34.09)
  IN1 w0.089: 120.87,31.9 124.07,28.7 124.07,25.14 125.1,24.11 125.1,23.88 125.5,23.49 125.5,22.54 125.14,22.18 125.14,21.11 125.32,20.93 125.71,20.93 126.01,20.62 126.01,20.29 126.18,20.12 127.92,20.12 v13(128.25,20.45)
  BOTTOM w0.147: v13(128.25,20.45) 127.94,20.14 U5A1.C9
M1_A_DQ37: length 17.3
  IN1 w0.06: 121.9,32.37 121.9,32.41 121.59,32.72 121.43,32.72 121.3,32.85 121.3,33.77 121.38,33.85 121.38,34.38 121.26,34.5 121.26,34.66 121.46,34.86 v11(121.46,35.07)
  IN1 w0.089: 121.9,32.37 125.72,28.54 125.72,26.79 128.26,24.26 128.26,23.89 128.34,23.81 128.71,23.81 128.82,23.7 128.82,23.31 128.54,23.03 128.54,22.3 v13(128.35,22.1)
  BOTTOM w0.147: v13(128.35,22.1) 128.32,22.07 128.32,22.07 U5A1.C11
M1_A_DQ38: length 18.7
  IN1 w0.06: v11(121.46,35.57) 121.57,35.46 121.57,35.25 121.66,35.16 121.66,34.99 121.59,34.91 121.59,34.74 121.91,34.42 121.91,32.76 122.97,31.7 123.3,31.7 123.36,31.65
  IN1 w0.089: v13(128.91,21.28) 129.29,21.66 129.29,22.21 129.59,22.51 129.59,22.57 129.6,22.58 129.6,23.87 126.38,27.08 126.38,28.62 123.36,31.65
  BOTTOM w0.147: v13(128.91,21.28) 128.89,21.25 128.89,21.19 U5A1.B10
M1_A_DQ39: length 22.2
  IN1 w0.06: v11(120.82,35.57) 120.7,35.44 120.7,35.23 120.62,35.16 120.62,34.99 120.7,34.91 120.7,34.62 120.62,34.54 120.62,33.58 120.69,33.51 120.69,31.82 120.77,31.73
  IN1 w0.089: 120.77,31.73 123.74,28.77 123.74,25.03 124.69,24.08 124.69,20.17 124.72,20.15 124.72,19.53 124.99,19.26 127.86,19.26 v13(128.25,19.66)
  BOTTOM w0.147: U5A1.C8 127.94,19.34 v13(128.25,19.66)
M1_A_DQ40: length 21.5
  IN1 w0.06: v11(120.5,34.83) 120.5,33.53 120.57,33.46 120.57,31.68 120.63,31.62
  IN1 w0.089: 120.63,31.62 123.23,29.02 123.23,24.42 123.87,23.78 123.87,20.15 122.69,18.97 120.68,18.97 119.93,19.72 v13(119.83,19.72)
  BOTTOM w0.147: U5A1.T8 119.49,19.38 119.83,19.72 v13(119.83,19.72)
M1_A_DQ41: length 19
  IN1 w0.06: v11(120.18,34.58) 120.26,34.5 120.26,33.43 120.33,33.36 120.33,31.38
  IN1 w0.089: 120.33,31.38 122.57,29.14 122.57,24.19 123.24,23.52 123.24,20.46 122.9,20.12 120.86,20.12 v13(120.48,20.51)
  BOTTOM w0.147: v13(120.48,20.51) 120.14,20.17 U5A1.R9
M1_A_DQ42: length 17.3
  IN1 w0.06: 120.01,30.23 119.32,30.93 119.32,34.24 119.33,34.25 119.33,35.15 119.45,35.27 119.52,35.27 119.82,35.57 v11(120.18,35.57)
  IN1 w0.089: 120.01,30.23 120.01,29.27 120.36,28.92 120.36,25.38 118.58,23.6 118.58,22.08 118.99,21.67 119.34,21.67 v13(119.73,21.29)
  BOTTOM w0.147: v13(119.73,21.29) 119.75,21.29 U5A1.R10
M1_A_DQ43: length 16
  TOP w0.06: U3.BN39 v11(119.53,34.09)
  IN1 w0.06: 120.24,30.26 119.44,31.06 119.44,31.23 119.48,31.28 119.59,31.28 119.65,31.34 119.65,31.44 119.59,31.5 119.5,31.5 119.44,31.56 119.44,31.67 119.5,31.73 119.6,31.73 119.66,31.79 119.66,31.9 119.6,31.96 119.5,31.96 119.44,32.02 119.44,32.13 119.5,32.19 119.57,32.19 119.63,32.25 119.63,32.36 119.57,32.42 119.49,32.42 119.44,32.47 119.44,33.59 119.63,33.79 119.63,33.99 v11(119.53,34.09)
  IN1 w0.089: v13(119.14,22.08) 119.3,22.24 119.3,22.41 119.2,22.51 118.89,22.51 118.82,22.59 118.82,23.53 119.15,23.87 119.61,23.87 119.72,23.98 119.72,24.3 120.67,25.25 120.67,28.89 120.24,29.32 120.24,30.26
  BOTTOM w0.147: U5A1.T11 119.14,22.05 v13(119.14,22.08)
M1_A_DQ44: length 20.7
  IN1 w0.06: 120.48,31.5 120.45,31.54 120.45,33.41 120.38,33.48 120.38,34.66 120.3,34.74 120.3,34.91 120.5,35.11 v11(120.5,35.32)
  IN1 w0.089: 120.48,31.5 122.9,29.08 122.9,24.31 123.56,23.65 123.56,20.28 122.59,19.31 120.87,19.31 v13(120.47,19.72)
  BOTTOM w0.147: v13(120.47,19.72) 120.14,19.39 U5A1.R8
M1_A_DQ45: length 19.4
  IN1 w0.06: v11(120.18,35.07) 120.18,34.86 119.98,34.66 119.98,34.5 120.14,34.33 120.14,33.59 119.93,33.38 119.93,32.93 120.16,32.7 120.16,31.26
  IN1 w0.089: v13(119.9,20.51) 120.28,20.89 122.78,20.89 122.93,21.04 122.93,23.35 122.24,24.04 122.24,29.18 120.16,31.26
  BOTTOM w0.147: v13(119.9,20.51) 119.49,20.1 U5A1.T9
M1_A_DQ46: length 16.4
  IN1 w0.06: 120.47,30.26 119.78,30.95 119.78,32.47 119.56,32.69 119.56,33.54 119.75,33.74 119.75,34.19 119.45,34.49 119.45,34.99 v11(119.53,35.07)
  IN1 w0.089: v13(119.72,22.09) 119.47,22.34 119.47,22.71 119.71,22.95 119.89,22.95 119.98,23.04 119.98,23.18 119.89,23.28 119.39,23.28 119.3,23.37 119.3,23.51 119.39,23.6 119.91,23.6 120.03,23.73 120.03,24.17 121,25.14 121,28.87 120.47,29.41 120.47,30.26
  BOTTOM w0.147: U5A1.R11 120.11,21.69 119.72,22.09 v13(119.72,22.09)
M1_A_DQ47: length 16.7
  IN1 w0.06: v11(119.53,35.57) 119.17,35.57 119.01,35.4 119.01,35.23 119.09,35.16 119.09,34.97 119.21,34.85 119.21,34.3 119.2,34.29 119.2,30.8 119.65,30.35
  IN1 w0.089: v13(119.14,21.28) 118.31,22.1 118.31,23.78 120.04,25.51 120.04,28.9 119.73,29.22 119.73,30.27 119.65,30.35
  BOTTOM w0.147: v13(119.14,21.28) 119.14,21.25 U5A1.T10
M1_A_DQ48: length 21.5
  IN2 w0.06: 116.16,32.18 116.25,32.26 116.25,35.52 115.99,35.78 v14(115.99,36.3)
  IN2 w0.109: 116.16,32.18 114.8,30.82 114.8,29.65 114.6,29.45 114.6,28.18 112.35,25.92 112.35,25.81 112.26,25.73 111.89,25.73 111.8,25.64 111.8,25.47 111.89,25.38 112.26,25.38 112.35,25.29 112.35,25.13 112.26,25.04 111.89,25.04 111.8,24.95 111.8,24.79 111.89,24.7 112.26,24.7 112.35,24.61 112.35,24.44 112.26,24.35 111.89,24.35 111.8,24.26 111.8,24.1 111.89,24.01 112.26,24.01 112.35,23.92 112.35,22.02 111.99,21.65 111.63,21.65 111.5,21.52 111.5,21 111.44,20.94 111.26,20.94 111.14,20.82 v13(111.14,20.48)
  BOTTOM w0.147: U4A1.B9 110.82,20.16 v13(111.14,20.48)
M1_A_DQ49: length 22
  IN2 w0.06: 116.22,31.99 116.37,32.13 116.37,35.58 116.2,35.75 116.2,36.76 116.16,36.8 v14(115.99,36.8)
  IN2 w0.109: v13(111.14,19.68) 111.14,20.02 111.28,20.15 112.08,20.15 112.17,20.24 112.17,20.37 112.08,20.45 111.77,20.45 111.68,20.54 111.68,20.7 111.77,20.78 112.53,20.78 112.62,20.87 112.62,21.03 112.53,21.11 112.34,21.11 112.24,21.22 112.24,21.52 112.64,21.93 112.64,25.8 114.89,28.05 114.89,29.42 114.99,29.52 114.99,30.75 116.22,31.99
  BOTTOM w0.147: U4A1.B8 110.82,19.36 v13(111.14,19.68)
M1_A_DQ50: length 21.6
  GND1 w0.06: v14(115.02,35.57) v12(115.02,36.06)
  IN2 w0.06: 114.95,32.75 114.95,35.3 115.02,35.37 v14(115.02,35.57)
  IN2 w0.109: v13(110.55,21.3) 110.16,20.9 109.07,20.9 108.88,21.09 108.88,21.48 108.67,21.7 107.79,21.7 107.63,21.86 107.63,22.3 107.98,22.65 107.98,23.7 107.94,23.75 107.94,25.05 112.44,29.56 112.44,30.23 114.95,32.75
  BOTTOM w0.147: U4A1.C10 110.46,21.18 110.46,21.2 v13(110.55,21.3)
M1_A_DQ51: length 21
  IN2 w0.06: 115.79,32.57 115.87,32.65 115.87,34.33 115.46,34.73 115.46,36.14 115.55,36.22 115.55,36.38 115.46,36.47 115.46,36.63 115.54,36.71 115.54,36.88 115.16,37.26 115.16,37.35 115.22,37.41 115.3,37.41 v14(115.67,37.04)
  IN2 w0.109: v13(110.54,22.07) 110.74,22.26 110.74,23.12 110.56,23.3 110.56,23.76 110.43,23.88 110.43,25.68 113.65,28.9 113.65,30.46 113.72,30.54 113.83,30.54 113.91,30.46 113.91,29.85 113.99,29.78 114.1,29.78 114.18,29.85 114.18,30.96 115.79,32.57
  BOTTOM w0.147: v13(110.54,22.07) U4A1.C11
M1_A_DQ52: length 21.4
  IN2 w0.06: v14(115.66,36.06) 115.72,36 115.72,35.82 115.61,35.71 115.61,34.79 115.67,34.73 115.76,34.73 115.82,34.79 115.82,35.39 115.88,35.45 115.95,35.45 116.01,35.39 116.01,32.53 115.91,32.43
  IN2 w0.109: v13(111.14,22.08) 111.14,22.42 111.53,22.8 111.53,23.12 111.4,23.25 110.86,23.25 110.79,23.32 110.79,23.48 110.86,23.55 111.2,23.55 111.27,23.63 111.27,23.81 111.2,23.88 110.88,23.88 110.79,23.97 110.79,24.15 110.88,24.24 111.08,24.24 111.17,24.33 111.17,24.48 111.08,24.57 110.83,24.57 110.74,24.66 110.74,24.81 110.83,24.9 111.09,24.9 111.17,24.98 111.17,25.13 111.09,25.2 110.81,25.2 110.72,25.29 110.72,25.45 110.81,25.53 111.07,25.53 111.17,25.64 111.17,26.01 114.02,28.85 114.02,29.45 114.37,29.8 114.37,30.89 115.91,32.43
  BOTTOM w0.147: v13(111.14,22.08) 111.12,22.05 111.12,21.99 U4A1.B11
M1_A_DQ53: length 21.7
  IN2 w0.06: v14(115.66,36.55) 115.71,36.5 115.71,36.3 115.87,36.14 115.87,35.72 116.13,35.46 116.13,32.4 116.03,32.3
  IN2 w0.109: 116.03,32.3 114.57,30.84 114.57,29.7 114.31,29.44 114.31,28.73 114.22,28.64 114.22,28.48 114.27,28.43 114.27,28.3 114.15,28.19 114.03,28.19 113.93,28.28 113.86,28.28 113.73,28.15 113.73,28.03 113.82,27.93 113.82,27.81 113.7,27.69 113.58,27.69 113.49,27.78 113.36,27.78 113.24,27.67 113.24,27.54 113.34,27.45 113.34,27.32 113.22,27.21 113.09,27.21 113,27.3 112.88,27.3 112.76,27.18 112.76,27.06 112.85,26.96 112.85,26.84 112.73,26.72 112.61,26.72 112.52,26.81 112.39,26.81 112.27,26.7 112.27,26.57 112.37,26.48 112.37,26.35 112.25,26.24 112.12,26.24 112.03,26.33 111.91,26.33 111.46,25.88 111.46,23.82 111.58,23.71 112.08,23.71 112.16,23.63 112.16,23.48 112.08,23.4 111.78,23.4 111.7,23.32 111.7,23.15 111.78,23.07 112.02,23.07 112.11,22.98 112.11,22.8 112.02,22.71 111.75,22.71 111.68,22.64 111.68,22.47 111.49,22.28 111.49,21.92 111.14,21.57 v13(111.14,21.28)
  BOTTOM w0.147: U4A1.B10 111.12,21.19 111.12,21.25 v13(111.14,21.28)
M1_A_DQ54: length 22.8
  IN2 w0.06: 114.75,32.82 114.81,32.89 114.81,35.7 115.02,35.91 115.02,36.55 v14(115.02,36.55)
  IN2 w0.109: 114.75,32.82 112.16,30.23 112.16,29.69 107.64,25.17 107.64,23.63 107.69,23.58 107.69,22.77 107.35,22.42 107.35,21.33 108.03,20.65 108.03,20.5 108.46,20.07 110.1,20.07 v13(110.48,20.45)
  BOTTOM w0.147: v13(110.48,20.45) 110.17,20.14 U4A1.C9
M1_A_DQ55: length 24.4
  IN2 w0.06: 114.39,32.75 114.69,33.05 114.69,35.75 114.82,35.88 114.82,36.14 114.9,36.22 114.9,36.39 114.82,36.47 114.82,36.64 115.02,36.84 v14(115.02,37.04)
  IN2 w0.109: 114.39,32.75 111.84,30.2 111.84,29.79 107.35,25.3 107.35,24.03 106.94,23.61 106.94,22.45 107.06,22.33 107.06,21.21 107.74,20.53 107.74,20.39 108.26,19.87 108.26,19.51 108.45,19.31 109.95,19.31 110.29,19.66 v13(110.48,19.66)
  BOTTOM w0.147: U4A1.C8 110.17,19.34 v13(110.48,19.66)
M1_A_DQ56: length 25.5
  IN2 w0.06: v14(114.7,36.3) 114.7,36.3 114.7,35.93 114.57,35.8 114.57,33.22 114.32,32.96
  IN2 w0.109: 114.32,32.96 106.22,24.86 106.22,20.68 104.54,19.01 102.15,19.01 v13(101.42,19.74)
  BOTTOM w0.147: U4A1.T8 101.42,19.6 v13(101.42,19.74)
M1_A_DQ57: length 25.5
  IN2 w0.06: v14(114.7,36.8) 114.58,36.68 114.58,36.47 114.5,36.39 114.5,36.22 114.58,36.14 114.58,35.98 114.45,35.85 114.45,33.51 114.17,33.23
  IN2 w0.109: v13(102.1,19.72) 102.52,19.3 104.42,19.3 105.38,20.26 105.38,20.61 105.48,20.71 105.83,20.71 105.91,20.79 105.91,20.96 105.84,21.04 105.68,21.04 105.61,21.11 105.61,21.32 105.68,21.39 105.84,21.39 105.91,21.47 105.91,24.97 114.17,33.23
  BOTTOM w0.147: U4A1.R8 102.1,19.57 v13(102.1,19.72)
M1_A_DQ58: length 24
  IN2 w0.06: v14(113.62,36.04) 113.47,35.89 113.47,35
  IN2 w0.109: 113.47,35 107.76,29.29 106.77,29.29 103.93,26.45 103.93,26.33 104.3,25.96 104.3,25.85 104.16,25.72 104.06,25.72 103.69,26.09 103.56,26.09 103.45,25.97 103.45,25.84 103.81,25.47 103.81,25.37 103.68,25.23 103.57,25.23 103.27,25.54 103.14,25.54 103.01,25.41 103.01,25.28 103.32,24.98 103.32,24.87 103.18,24.74 103.08,24.74 102.82,25 102.71,25 102.56,24.85 102.56,24.74 102.78,24.53 102.78,24.4 102.66,24.29 102.53,24.29 102.33,24.49 102.19,24.49 101.78,24.08 101.78,23.16 102.02,22.93 v13(102.02,22.11)
  BOTTOM w0.147: U4A1.R11 102.37,21.79 102.05,22.11 v13(102.02,22.11)
M1_A_DQ59: length 25.3
  IN2 w0.06: v14(114.38,37.04) 114.02,37.04 113.73,36.75 113.65,36.75 113.3,36.4 113.3,36.35 113.07,36.12 113.07,35.43
  IN2 w0.109: v13(101.3,22.1) 101.06,21.86 101.06,21.61 100.97,21.52 100.82,21.52 100.73,21.61 100.73,22 100.65,22.08 100.45,22.08 100.37,22 100.37,21.66 100.29,21.57 100.11,21.57 100.02,21.66 100.02,23.15 102.02,25.15 102.02,25.37 106.53,29.88 107.52,29.88 113.07,35.43
  BOTTOM w0.147: U4A1.T11 101.7,21.69 v13(101.3,22.1)
M1_A_DQ60: length 24.8
  IN2 w0.06: v14(114.38,36.55) 114.38,36.34 114.18,36.14 114.18,34.26 114.07,34.14 114.07,33.95
  IN2 w0.109: v13(101.37,20.48) 101.37,20.66 101.56,20.85 102.96,20.85 103.04,20.94 103.04,21.56 103.18,21.7 104.18,21.7 104.33,21.84 104.33,24.19 104.4,24.26 104.62,24.26 104.69,24.19 104.69,23.78 104.77,23.71 104.97,23.71 105.05,23.78 105.05,24.93 114.07,33.95
  BOTTOM w0.147: U4A1.T9 101.72,20.12 v13(101.37,20.48)
M1_A_DQ61: length 24.8
  IN2 w0.06: v14(114.38,36.06) 114.33,36.01 114.33,34.01 114.24,33.92 114.24,33.71 ; 104.9,21.66 104.9,20.98
  IN2 w0.109: v13(102.05,20.48) 102.47,20.06 104.77,20.06 105.09,20.39 105.09,20.79 104.9,20.98 ; 114.24,33.71 105.62,25.09 105.62,22.46 105.57,22.41 105.15,22.41 105.07,22.33 105.07,22.16 105.15,22.08 105.53,22.08 105.61,22 105.61,21.83 105.53,21.75 105,21.75 104.9,21.66
  BOTTOM w0.147: U4A1.R9 102.37,20.16 v13(102.05,20.48)
M1_A_DQ62: length 24.4
  IN2 w0.06: 112.77,35.54 112.77,36.04 113.73,37 v14(113.73,37.04)
  IN2 w0.109: 112.77,35.54 107.4,30.17 106.4,30.17 101.73,25.49 101.73,25.27 99.59,23.13 99.59,21.47 99.78,21.28 v13(101.37,21.28)
  BOTTOM w0.147: U4A1.T10 101.37,21.25 v13(101.37,21.28)
M1_A_DQ63: length 24.3
  IN2 w0.06: 113.31,35.25 113.31,36.13 v14(113.73,36.55)
  IN2 w0.109: 113.31,35.25 107.64,29.58 106.65,29.58 102.31,25.25 102.31,25.03 101.52,24.23 101.52,23.62 101.43,23.53 100.81,23.53 100.73,23.45 100.73,23.25 100.81,23.17 101,23.17 101.09,23.08 101.09,22.93 101,22.84 100.49,22.84 100.4,22.75 100.4,22.58 100.49,22.49 101.57,22.49 101.66,22.4 101.66,21.67 v13(102.05,21.28)
  BOTTOM w0.147: v13(102.05,21.28) 102.05,21.22 U4A1.R10
M1_A_DQSN0: length 23.2
  IN2 w0.06: v14(119.85,36.8) 119.85,36.59 120.05,36.39 120.05,36.22 119.97,36.14 119.97,35.88 119.83,35.74 119.83,35.08 119.79,35.04 119.79,33.32 119.88,33.24 120.22,33.24 120.35,33.11 120.35,32.89 120.22,32.76 119.88,32.76 119.82,32.7 119.82,32.58 119.88,32.52 120.22,32.52 120.35,32.39 120.35,32.17 120.22,32.04 119.88,32.04 119.82,31.98 119.82,31.8 119.9,31.72 120.16,31.72 120.43,31.45 120.47,31.45 120.48,31.43
  IN2 w0.109: 120.55,31.38 120.54,31.39 120.52,31.39 120.48,31.43
  IN2 w0.114: v13(122.51,22.09) 122.51,22.16 122.06,22.61 122.06,22.8 122.13,22.86 122.35,22.86 122.57,23.09 122.57,23.49 122.35,23.71 122.07,23.71 121.96,23.81 121.96,24.04 122.07,24.14 122.63,24.14 122.85,24.36 122.85,24.77 122.65,24.98 122.29,24.98 122.19,25.08 122.19,25.36 122.28,25.44 122.68,25.44 122.9,25.66 122.9,26.12 122.68,26.34 122.35,26.34 122.24,26.44 122.24,26.73 122.35,26.83 122.78,26.83 122.88,26.93 122.88,27.51 122.66,27.73 122.37,27.73 122.27,27.83 122.27,28.12 122.37,28.22 122.64,28.22 122.88,28.46 122.88,28.74 122.31,29.31 122.31,29.62 120.55,31.38
  BOTTOM w0.147: v13(122.51,22.09) 122.41,21.99 122.41,21.83 122.54,21.69 U5A1.L11
M1_A_DQSN1: length 20.3
  IN2 w0.06: 121.8,33.05 121.8,33.05 121.68,33.05 121.56,33.18 121.56,34.81 121.19,35.17 121.19,36.07 121.34,36.22 121.34,36.39 121.26,36.47 121.26,36.68 v14(121.14,36.8)
  IN2 w0.114: v13(125.66,22.08) 125.66,22.37 126.08,22.79 126.08,23.77 126.21,23.9 127.05,23.9 127.27,24.12 127.27,24.56 127.05,24.78 126.19,24.78 126.1,24.86 126.1,25.4 126.3,25.59 126.3,26.1 126.08,26.32 126.08,26.69 126.3,26.92 126.3,27.58 126.1,27.78 126.1,28.75 121.8,33.05
  BOTTOM w0.147: U5A1.G11 125.22,21.82 125.22,22 125.29,22.08 v13(125.66,22.08)
M1_A_DQSN2: length 22.9
  IN1 w0.06: 115.5,32.3 115.61,32.41 115.61,33.43 115.47,33.58 115.47,34.4 115.47,34.4 115.47,34.67 115.54,34.74 115.54,34.91 115.43,35.03 115.28,35.03 115.22,35.08 115.22,35.16 115.16,35.22 115.16,35.29 115.23,35.36 115.3,35.36 v11(115.34,35.32)
  IN1 w0.089: v13(107.98,22.1) 107.98,22.35 108.22,22.58 108.22,23.55 108.45,23.78 109.39,23.78 109.59,23.99 109.59,24.45 109.39,24.66 108.44,24.66 108.32,24.78 108.32,25.12 108.44,25.23 109.76,25.23 109.95,25.43 109.95,25.91 109.73,26.13 108.94,26.13 108.83,26.25 108.83,26.54 108.94,26.65 110.77,26.65 113.13,29.01 113.13,29.92 115.5,32.3
  BOTTOM w0.147: U4A1.G11 107.89,22.02 v13(107.98,22.1)
M1_A_DQSN3: length 22.9
  IN1 w0.06: 113.53,33.56 113.58,33.61 113.58,33.61 113.58,33.91 114.14,34.47 114.14,34.75 v11(114.06,34.83)
  IN1 w0.089: v13(104.57,21.29) 104.78,21.29 105.07,21.58 105.07,22.27 104.62,22.73 104.62,24.35 104.49,24.48 103.74,24.48 103.52,24.7 103.52,25.19 103.74,25.41 104.45,25.41 104.57,25.52 104.57,25.81 104.43,25.95 104.19,25.95 103.98,26.16 103.98,26.62 104.19,26.83 104.53,26.83 104.66,26.96 104.66,27.38 107.29,30 109.19,30 109.77,30.59 110.56,30.59 113.53,33.56
  BOTTOM w0.147: U4A1.L11 104.97,21.57 104.86,21.45 104.86,21.4 104.75,21.29 v13(104.57,21.29)
M1_A_DQSN4: length 20.3
  IN1 w0.06: 121.49,31.94 121.41,32.02 121.41,32.04 121.06,32.39 121.06,33.87 121.14,33.95 121.14,34.28 121.02,34.4 121.02,34.66 120.94,34.74 120.94,34.91 121.06,35.03 121.13,35.03 121.38,35.27 121.38,35.36 121.34,35.41 121.2,35.41 121.14,35.35 v11(121.14,35.32)
  IN1 w0.089: 121.49,31.94 124.99,28.44 124.99,26.51 125.33,26.17 125.33,26.01 125.08,25.77 125.08,25.4 125.39,25.09 125.72,25.09 125.98,25.35 126.14,25.35 126.35,25.15 126.35,24.96 125.93,24.54 125.93,24.23 126.25,23.91 126.58,23.91 127,24.33 127.18,24.33 127.57,23.95 127.57,23.78 126.95,23.17 126.95,22.87 127.25,22.57 127.47,22.57 127.63,22.41 v13(127.63,22.1)
  BOTTOM w0.147: U5A1.D11 127.63,22.03 v13(127.63,22.1)
M1_A_DQSN5: length 19.6
  IN1 w0.06: v11(119.85,34.83) 119.85,34.83 119.77,34.75 119.77,34.5 119.99,34.28 119.99,33.62 119.79,33.42 119.79,32.86 120.02,32.64 120.02,31.17 120.95,30.24 120.95,29.92 120.99,29.88 120.99,29.86
  IN1 w0.089: v13(121.18,21.32) 120.94,21.32 120.34,21.92 120.34,22.43 120.43,22.52 122.1,22.52 122.32,22.74 122.32,23.23 122.1,23.45 120.92,23.45 120.82,23.55 120.82,23.89 120.95,24.02 121.53,24.02 121.7,24.19 121.7,29 120.99,29.71 120.99,29.86
  BOTTOM w0.147: v13(121.18,21.32) 121.15,21.29 120.87,21.29 120.82,21.35 120.82,21.67 U5A1.P11
M1_A_DQSN6: length 24
  IN2 w0.06: 115.48,32.86 115.5,32.86 115.54,32.9 115.63,32.99 115.63,33.12 115.57,33.18 115.23,33.18 115.09,33.33 115.09,33.62 115.23,33.76 115.57,33.76 115.63,33.82 115.63,34.23 115.22,34.63 115.22,35.82 115.14,35.9 115.14,36.39 115.26,36.5 115.31,36.5 115.34,36.54 115.34,36.79 v14(115.34,36.8)
  IN2 w0.109: 115.46,32.85 115.48,32.86
  IN2 w0.114: v13(109.83,22.11) 109.97,22.25 110,22.28 110,22.38 109.92,22.46 108.7,22.46 108.48,22.68 108.48,23.1 108.7,23.32 109.57,23.32 109.67,23.43 109.67,23.68 109.62,23.73 108.66,23.73 108.48,23.91 108.48,24.42 108.66,24.59 109.65,24.59 109.75,24.7 109.75,24.99 109.65,25.09 109.55,25.09 109.36,25.27 109.36,25.66 112.92,29.22 112.92,30.3 115.46,32.85
  BOTTOM w0.147: v13(109.83,22.11) 109.91,22.02 109.91,21.85 109.87,21.8 109.87,21.78 109.8,21.71 109.54,21.71 U4A1.D11
M1_A_DQSN7: length 24.1
  IN2 w0.06: 113.93,34.48 113.94,34.48 113.94,34.57 114.04,34.68 114.04,35.59 113.94,35.69 113.94,35.83 113.99,35.87 114.02,35.87 114.06,35.9 114.06,36.02 114.02,36.05 114,36.05 113.94,36.1 113.94,36.31 113.99,36.35 v14(114.1,36.35)
  IN2 w0.114: v13(102.79,22.09) 102.65,22.09 102.58,22.16 102.58,22.46 102.66,22.54 102.99,22.54 103.07,22.61 103.07,22.72 102.99,22.8 102.69,22.8 102.64,22.84 102.64,22.94 102.99,23.29 102.99,23.55 105.22,25.79 105.22,26.08 104.95,26.36 104.95,26.5 105.15,26.7 105.29,26.7 105.52,26.48 105.58,26.42 105.87,26.42 106.17,26.73 106.17,27.02 105.92,27.28 105.92,27.42 106.12,27.62 106.27,27.62 106.52,27.37 106.81,27.37 107.13,27.68 107.13,27.99 106.87,28.25 106.87,28.34 107.1,28.56 107.18,28.56 107.46,28.28 107.73,28.28 113.93,34.48
  BOTTOM w0.147: U4A1.P11 102.96,21.63 102.72,21.63 102.68,21.67 102.68,21.98 v13(102.79,22.09)
M1_A_DQSP0: length 23.1
  IN2 w0.06: v14(119.85,36.3) 119.85,35.93 119.71,35.79 119.71,35.13 119.67,35.09 119.67,33.27 119.83,33.12 120.17,33.12 120.23,33.06 120.23,32.94 120.17,32.88 119.83,32.88 119.7,32.75 119.7,32.53 119.83,32.4 120.17,32.4 120.23,32.34 120.23,32.22 120.17,32.16 119.83,32.16 119.7,32.03 119.7,31.75 119.85,31.6 120.11,31.6 120.18,31.52 120.38,31.33 120.38,31.31
  IN2 w0.086: 120.38,31.26 120.38,31.31
  IN2 w0.109: 120.4,31.24 120.38,31.26
  IN2 w0.114: v13(122.48,21.28) 122.14,21.62 122.14,22.25 121.86,22.53 121.86,22.88 122.05,23.07 122.27,23.07 122.37,23.17 122.37,23.4 122.27,23.5 121.98,23.5 121.76,23.73 121.76,24.12 121.98,24.34 122.55,24.34 122.65,24.44 122.65,24.69 122.57,24.77 122.21,24.77 121.99,24.99 121.99,25.44 122.19,25.65 122.6,25.65 122.7,25.75 122.7,26.04 122.6,26.14 122.26,26.14 122.04,26.36 122.04,26.81 122.26,27.03 122.57,27.03 122.68,27.14 122.68,27.42 122.57,27.52 122.29,27.52 122.07,27.75 122.07,28.2 122.29,28.42 122.56,28.42 122.68,28.54 122.68,28.66 122.1,29.23 122.1,29.53 120.4,31.24
  BOTTOM w0.147: U5A1.L10 122.48,21.16 v13(122.48,21.28)
M1_A_DQSP1: length 20.3
  IN2 w0.06: 121.66,32.9 121.44,33.13 121.44,34.76 121.07,35.12 121.07,36.23 v14(121.14,36.3)
  IN2 w0.114: 121.66,32.9 125.9,28.66 125.9,27.69 126.1,27.5 126.1,27 125.88,26.78 125.88,26.24 126.09,26.02 126.09,25.68 125.9,25.48 125.9,24.77 126.1,24.57 126.97,24.57 127.07,24.47 127.07,24.2 126.97,24.1 126.12,24.1 125.87,23.86 125.87,22.87 125.3,22.3 125.3,21.79 125.66,21.43 v13(125.66,21.28)
  BOTTOM w0.147: U5A1.G10 125.66,21.22 v13(125.66,21.28)
M1_A_DQSP2: length 22.9
  IN1 w0.06: 115.32,32.37 115.49,32.54 115.49,33.38 115.35,33.53 115.35,33.98 115.35,34.71 115.34,34.71 v11(115.34,34.83)
  IN1 w0.089: 115.32,32.37 112.95,29.99 112.95,29.09 110.69,26.83 108.87,26.83 108.65,26.61 108.65,26.17 108.87,25.96 109.66,25.96 109.77,25.84 109.77,25.5 109.68,25.41 108.37,25.41 108.15,25.19 108.15,24.7 108.37,24.48 109.32,24.48 109.42,24.38 109.42,24.06 109.32,23.96 108.38,23.96 108.04,23.63 108.04,22.66 107.63,22.25 107.63,21.63 v13(107.94,21.32)
  BOTTOM w0.147: v13(107.94,21.32) 107.89,21.27 107.89,21.22 U4A1.G10
M1_A_DQSP3: length 22.9
  IN1 w0.06: 113.64,33.45 113.64,33.46 113.64,33.48 113.67,33.5 113.67,33.53 113.7,33.56 113.7,33.86 114.26,34.42 114.26,34.91 114.06,35.11 v11(114.06,35.32)
  IN1 w0.089: 113.64,33.45 113.64,33.41 110.63,30.41 109.85,30.41 109.26,29.83 107.36,29.83 104.83,27.3 104.83,26.89 104.6,26.65 104.26,26.65 104.16,26.55 104.16,26.23 104.26,26.13 104.5,26.13 104.74,25.89 104.74,25.45 104.53,25.23 103.82,25.23 103.7,25.11 103.7,24.77 103.82,24.66 104.56,24.66 104.79,24.43 104.79,22.8 105.25,22.34 v13(105.25,21.27)
  BOTTOM w0.147: U4A1.L10 104.97,20.99 v13(105.25,21.27)
M1_A_DQSP4: length 20.3
  IN1 w0.06: 121.56,32.12 121.55,32.13 121.49,32.13 121.18,32.44 121.18,33.83 121.26,33.91 121.26,34.33 121.14,34.45 121.14,34.62 121.14,34.63 v11(121.14,34.83)
  IN1 w0.089: 121.56,32.12 125.17,28.52 125.17,26.58 125.5,26.24 125.5,25.94 125.26,25.69 125.26,25.48 125.47,25.27 125.65,25.27 125.91,25.53 126.22,25.53 126.53,25.22 126.53,24.89 126.11,24.47 126.11,24.3 126.32,24.09 126.5,24.09 126.93,24.51 127.26,24.51 127.74,24.02 127.74,23.71 127.12,23.09 127.12,22.95 127.32,22.75 127.54,22.75 127.99,22.3 127.99,21.98 127.61,21.6 v13(127.61,21.31)
  BOTTOM w0.147: v13(127.61,21.31) 127.61,21.21 U5A1.D10
M1_A_DQSP5: length 19.5
  IN1 w0.06: 120.81,29.83 120.81,29.91 120.83,29.93 120.83,30.19 119.9,31.12 119.9,32.59 119.67,32.81 119.67,33.47 119.88,33.67 119.88,34.23 119.65,34.45 119.65,34.91 119.85,35.11 v11(119.85,35.32)
  IN1 w0.089: v13(120.41,21.31) 120.41,21.6 120.16,21.84 120.16,22.5 120.36,22.7 122.03,22.7 122.14,22.82 122.14,23.15 122.03,23.27 120.85,23.27 120.64,23.48 120.64,23.97 120.88,24.2 121.46,24.2 121.52,24.26 121.52,28.93 120.81,29.64 120.81,29.83
  BOTTOM w0.147: U5A1.P10 120.41,21.28 v13(120.41,21.31)
M1_A_DQSP6: length 24.1
  IN2 w0.06: 115.61,32.7 115.63,32.73 115.63,32.81 115.75,32.92 115.75,33.17 115.62,33.3 115.28,33.3 115.21,33.38 115.21,33.57 115.28,33.64 115.62,33.64 115.75,33.77 115.75,34.28 115.34,34.68 115.34,35.87 115.26,35.95 115.26,36.22 v14(115.34,36.3)
  IN2 w0.114: 115.61,32.7 113.12,30.22 113.12,29.13 109.57,25.58 109.57,25.35 109.63,25.29 109.73,25.29 109.95,25.07 109.95,24.61 109.73,24.39 108.74,24.39 108.68,24.33 108.68,24 108.74,23.94 109.7,23.94 109.87,23.76 109.87,23.34 109.65,23.12 108.78,23.12 108.68,23.02 108.68,22.77 108.78,22.66 110,22.66 110.2,22.46 110.2,22.22 110.2,22.21 110.2,21.68 v13(109.82,21.31)
  BOTTOM w0.147: U4A1.D10 109.82,21.2 v13(109.82,21.31)
M1_A_DQSP7: length 24.1
  IN2 w0.06: 113.8,34.64 113.81,34.64 113.92,34.75 113.92,35.54 113.82,35.64 113.82,36.36 114.06,36.59 v14(114.06,36.8)
  IN2 w0.114: 113.8,34.64 107.65,28.48 107.55,28.48 107.26,28.76 107.01,28.76 106.67,28.42 106.67,28.17 106.92,27.91 106.92,27.77 106.73,27.57 106.61,27.57 106.35,27.83 106.04,27.83 105.71,27.5 105.71,27.19 105.97,26.93 105.97,26.81 105.78,26.63 105.66,26.63 105.38,26.91 105.07,26.91 104.74,26.58 104.74,26.27 105.02,25.99 105.02,25.87 102.79,23.63 102.79,23.37 102.38,22.97 102.38,21.54 v13(102.69,21.23)
  BOTTOM w0.147: U4A1.P10 v13(102.69,21.23)
M1_A_ODT: length 46.5
  IN2 w0.06: v3(118.24,37.04) 118.24,36.84 118,36.6 117.84,36.6 117.72,36.48 117.72,36.22 117.76,36.18 117.8,36.14 117.8,35.82 118.04,35.58 118.04,32.84 117.61,32.41
  IN2 w0.109: v4(115.08,18.96) 115.39,19.26 115.39,24.7 115.46,24.77 115.69,24.77 115.77,24.7 115.77,21.72 115.84,21.65 116.07,21.65 116.15,21.72 116.15,25.48 117.61,26.94 117.61,32.41
  IN3 w0.109: v13(124.37,19.69) 123.16,19.69 122.42,18.96 v4(115.08,18.96) 106.47,18.96 106.24,19.18 106.24,19.34 v13(106.6,19.69)
  BOTTOM w0.102: v13(106.6,19.69) 106.6,19.62 U4A1.J8 ; U5A1.J8 124.37,19.62 v13(124.37,19.69)
M1_A_ZQ0: length 6.2
  BOTTOM w0.102: U5A1.B3 128.59,15.13 128.87,14.85 128.87,14.17 129.05,13.99 129.46,13.99 129.77,13.67
  BOTTOM w0.117: v4(132.5,12.13) R5L2.2 132.18,13.34 131.97,13.34 131.64,13.67 129.77,13.67
M1_A_ZQ1: length 5.5
  BOTTOM w0.102: U5A1.B4 128.59,16.08 128.96,15.71 128.96,15.17 129.72,14.41 129.77,14.41
  BOTTOM w0.117: R5L1.2 v4(132.07,13.99) 130.2,13.99 129.77,14.41
M1_B_A0: length 41.6
  IN2 w0.06: v14(118.89,36.06) 118.81,35.98 118.81,30.65
  IN2 w0.109: v13(102.05,14.15) 102.59,14.15 104.44,12.29 104.76,12.29 104.85,12.38 104.85,12.58 104.94,12.67 105.1,12.67 105.19,12.58 105.19,12.38 105.28,12.29 105.45,12.29 105.53,12.38 105.53,12.58 105.62,12.67 105.79,12.67 105.88,12.58 105.88,12.38 105.97,12.29 107.65,12.29 108.01,11.93 114.6,11.93 118.11,15.45 118.11,17.51 118.5,17.9 118.5,23.21 119.18,23.9 119.18,25.75 119.62,26.19 119.62,29.83 118.81,30.65
  BOTTOM w0.102: v13(102.05,14.15) 102.37,14.47 U4A1.R2
M1_B_A1: length 41.6
  IN2 w0.06: v14(118.89,36.55) 118.89,36.34 119.06,36.17 119.09,36.14 119.09,35.98 118.93,35.82 118.93,30.81 119.15,30.59
  IN2 w0.109: v13(102.71,13.52) 104.72,11.51 107.49,11.51 107.61,11.64 114.72,11.64 118.81,15.73 118.81,17.45 118.79,17.48 118.79,23.09 119.48,23.78 119.48,25.63 119.92,26.07 119.92,29.82 119.15,30.59
  BOTTOM w0.102: v13(102.71,13.52) 102.71,14.19 U4A1.P2
M1_B_A2: length 41.6
  IN2 w0.06: v3(118.89,37.04) 118.89,36.83 118.69,36.63 118.69,36.47 118.77,36.39 118.77,36.22 118.69,36.14 118.69,32.29 118.64,32.24 118.64,30.54
  IN2 w0.109: 118.64,30.54 119.33,29.84 119.33,26.31 118.89,25.87 118.89,24.02 118.21,23.33 118.21,18.02 117.82,17.63 117.82,15.57 114.49,12.24 108.46,12.24 108.32,12.38 108.32,12.89 108.25,12.96 108.05,12.96 107.97,12.89 107.97,12.68 107.88,12.59 107.72,12.59 107.63,12.68 107.63,12.87 107.54,12.96 107.37,12.96 107.28,12.87 107.28,12.68 107.19,12.59 107.03,12.59 106.94,12.68 106.94,12.87 106.85,12.96 106.69,12.96 106.6,12.87 106.6,12.78 106.52,12.71 106.33,12.71 106.25,12.78 106.25,12.87 106.17,12.96 104.29,12.96 v13(103.24,14)
  BOTTOM w0.102: v13(103.24,14) 103.24,14.05 103.67,14.48 U4A1.N2
