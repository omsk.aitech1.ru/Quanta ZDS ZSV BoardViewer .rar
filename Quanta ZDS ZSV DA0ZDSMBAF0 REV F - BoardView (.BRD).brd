# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VIN_VCCSA on TOP (solid shape): 162.88,50.91 162.88,50.12 162.55,49.79 162.55,47.86 162.4,47.71 161.55,47.71 161.55,47.97 160.05,47.97 160.05,47.72 159.71,47.38 159.71,46.78 159.38,46.45 157.76,46.45 157.45,46.76 157.45,48.9 157.4,48.96 156.94,48.96 156.74,49.16 156.74,49.6 156.81,49.67 161.16,49.67 161.97,50.49 161.97,50.91 162.1,51.04 162.76,51.04
GND on TOP (solid shape): 184.92,59.16 184.92,57.48 177.9,57.48 177.9,58.49 183.91,58.49 183.91,59.39 184.69,59.39
GND on TOP (solid shape): 46.58,53.22 46.58,50.97 46.13,50.53 45.57,50.53 44.65,51.45 44.65,53.58 44.77,53.7 46.09,53.7
GND on TOP (solid shape): 58.05,46.61 58.05,46.08 57.93,45.96 56.84,45.96 56.71,46.1 56.71,46.65 56.83,46.77 57.89,46.77
GND on TOP (solid shape): 63.75,41.19 63.75,39.66 63.42,39.33 61.74,39.33 61.7,39.38 61.7,41.05 61.94,41.29 63.65,41.29
GND on TOP (solid shape): 70.56,33.54 70.56,32.6 70.15,32.19 68.55,32.19 67.97,32.77 67.97,33.34 68.32,33.7 70.4,33.7
GND on TOP (solid shape): 123.79,44.94 123.79,44.82 123.66,44.69 120.62,44.69 120.49,44.82 120.49,44.94 120.62,45.07 123.66,45.07
GND on TOP (solid shape): 79.93,37.43 79.93,36.69 79.09,35.85 76.7,35.85 76.45,36.11 76.45,37.45 76.58,37.58 79.78,37.58
GND on TOP (solid shape): 198.17,57.48 189.63,57.48 189.63,58.81 190.03,59.21 190.64,59.21 190.64,58.49 197.16,58.49 197.16,59.35 198.17,59.35
GND on TOP (solid shape): 37.26,33.36 37.88,33.36 37.98,33.26 37.98,32.66 37.74,32.41 36.4,32.41 36.25,32.55 36.25,33.74 36.34,33.82 36.8,33.82
GND on TOP (solid shape): 49.44,35.18 49.44,32.83 49.23,32.62 48.05,32.62 47.95,32.72 47.95,34.01 48.88,34.95 48.88,35.18 49.05,35.36 49.27,35.36
GND on TOP (solid shape): 52.9,59.83 52.9,58.38 52.62,58.1 46.09,58.1 46.03,58.17 46.03,58.63 45.99,58.63 45.99,59.41 46.57,59.98 52.74,59.98
GND on TOP (solid shape): 54.2,44.13 54.2,42.4 54.12,42.32 53.97,42.32 53.79,42.5 53.79,43.64 53.38,44.05 53.38,44.41 53.56,44.58 53.74,44.58
GND on TOP (solid shape): 54.3,47.11 54.3,44.99 54.07,44.76 52.88,44.76 52.47,45.17 52.47,47.15 52.58,47.26 54.15,47.26
GND on TOP (solid shape): 57.58,33.36 57.58,32.14 57.32,31.88 54.91,31.88 54.75,32.05 54.75,33.41 54.9,33.56 57.37,33.56
GND on TOP (solid shape): 70.07,54.85 70.07,52.87 70,52.8 68.14,52.8 67.89,53.05 67.89,54.41 68.07,54.59 68.83,54.59 69.21,54.97 69.95,54.97
GND on TOP (solid shape): 76.4,53.28 76.4,51.48 76.3,51.37 75.2,51.37 75.1,51.48 75.1,53.56 75.18,53.64 76.04,53.64
GND on TOP (solid shape): 159.94,52.14 159.94,51.78 159.3,51.15 157.58,51.15 157.47,51.25 157.47,51.73 157.37,51.83 157.37,52.24 157.47,52.34 159.74,52.34
GND on TOP (solid shape): 92.91,28.38 92.91,26.96 91.79,25.84 90.05,25.84 89.99,25.78 89.41,25.78 89.15,26.04 89.15,28.79 89.66,29.29 91.99,29.29
GND on TOP (solid shape): 36.28,51.83 37.45,51.83 37.81,51.46 37.81,49.71 37.62,49.52 37.27,49.52 36.87,49.92 36.35,49.92 36.22,50.06 36.22,51.8 36.25,51.83
GND on TOP (solid shape): 81.05,59.6 81.05,56.15 80.84,55.95 80.84,54.75 80.75,54.66 79.51,54.66 79.45,54.73 79.45,59.73 79.57,59.86 80.79,59.86
GND on TOP (solid shape): 154.79,55.74 154.79,54.74 155,54.54 155.47,54.54 155.62,54.39 155.62,53.4 155.32,53.1 153.33,53.1 153.11,53.33 153.11,55.74 153.28,55.92 154.61,55.92
GND on TOP (solid shape): 157.8,54.6 157.8,53.91 157.75,53.86 157.17,53.86 156.94,53.63 156.94,53.13 156.92,53.1 156.74,53.1 156.66,53.18 156.66,53.63 156.31,53.99 156.31,54.63 156.38,54.7 157.7,54.7
GND on TOP (solid shape): 54.37,35.82 54.37,35.08 54.49,34.97 54.49,32.76 54.38,32.66 53.57,32.66 53.29,32.94 53.29,34.02 51.95,35.36 51.95,35.78 52.12,35.95 54.24,35.95
GND on TOP (solid shape): 62.39,47.35 62.39,46.69 62.57,46.51 63.04,46.51 63.07,46.49 63.07,45.35 62.15,45.35 62.03,45.46 59.78,45.46 59.65,45.59 59.65,46.72 60.36,47.43 62.31,47.43
GND on TOP (solid shape): 86.33,51.88 86.33,51.52 86.15,51.34 84.91,51.34 84.86,51.29 84.86,50.3 84.8,50.25 77.62,50.25 77.57,50.3 77.57,51.67 77.9,52.01 86.2,52.01
GND on TOP (solid shape): 164.92,49.65 164.92,48.85 163.65,47.58 163.65,45.55 163.47,45.37 162.99,45.37 162.81,45.55 162.81,49.62 163.09,49.9 163.09,50.58 163.27,50.76 163.81,50.76
GND on TOP (solid shape): 58.87,19.09 58.9,19.02 58.9,17.6 57.97,16.67 56.92,16.67 56.91,16.67 56.6,16.67 55.7,17.58 55.7,17.89 55.49,18.09 55.49,18.09 55.02,18.56 55.02,19.24 55.19,19.4 56.07,19.4 56.5,19.83 58.12,19.83
GND on TOP (solid shape): 59.21,54.05 59.75,53.46 60.38,52.98 60.4,52.97 60.4,52.13 60.29,52.03 57.73,52.03 57.59,52.16 57.59,54.26 57.75,54.41 58.85,54.41
GND on TOP (solid shape): 124.56,40.94 124.56,40.81 124.44,40.7 124.44,40.45 124.55,40.34 124.55,40.16 124.48,40.1 124.37,40.1 124.24,40.23 120.56,40.23 120.52,40.26 120.52,40.44 120.58,40.5 123.96,40.5 124.04,40.59 124.04,40.59 124.29,40.84 124.29,40.94 124.37,41.02 124.48,41.02
GND on TOP (solid shape): 79.32,45.1 79.32,43.04 78.89,42.61 76.78,42.61 76.75,42.64 76.75,43.2 77.02,43.46 77.02,43.46 77.6,44.04 77.6,44.49 77.52,44.58 76.82,44.58 76.76,44.64 76.76,45.31 76.83,45.38 79.04,45.38
GND on TOP (solid shape): 115.47,37.82 115.47,37.75 115.42,37.7 115.42,37.37 115.47,37.31 115.47,37.26 115.39,37.19 115.29,37.19 115.24,37.24 115.24,37.34 115.26,37.37 115.26,37.7 115.14,37.82 114.91,37.82 114.76,37.67 114.63,37.67 114.4,37.9 114.32,37.9 114.25,37.98 114.25,38.08 114.58,38.41 114.88,38.41
GND on TOP (solid shape): 123.84,34.35 124.25,34.35 124.32,34.43 124.4,34.43 124.49,34.34 124.49,33.03 124.35,32.9 123.86,32.9 123.63,33.13 123.63,34.18 123.61,34.2 123.61,34.35 123.69,34.43 123.76,34.43
GND on TOP (solid shape): 121.3,34.42 121.36,34.42 121.37,34.42 121.46,34.39 121.55,34.42 121.57,34.42 121.58,34.42 121.61,34.45 121.84,34.45 121.91,34.37 121.91,34.25 121.66,33.99 121.66,33.33 121.61,33.28 121.41,33.28 121.33,33.36 121.33,33.87 121,34.2 121,34.45 121.02,34.48 121.25,34.48
GND on TOP (solid shape): 208.54,61.49 208.86,61.34 208.99,61 208.99,58.51 202.99,58.51 202.99,55.69 208.99,55.69 208.99,54.7 201.28,54.7 200.7,55.28 200.7,61.22 200.97,61.49 201.31,61.49 201.31,61.49
GND on TOP (solid shape): 114.83,46.44 115.19,46.44 115.26,46.51 115.41,46.51 115.46,46.47 115.46,46.34 115.41,46.29 115.05,46.29 114.85,46.09 114.85,43.64 114.85,43.64 114.77,43.57 114.66,43.57 114.61,43.62 114.61,45.08 114.46,45.23 113.66,45.23 113.62,45.27 113.62,45.5 113.68,45.56 114.41,45.56 114.59,45.74 114.59,45.77 114.61,45.8 114.61,46.11 114.59,46.14 114.59,46.51 114.62,46.54 114.74,46.54
GND on TOP (solid shape): 119.3,37.85 119.3,36.83 119.31,36.82 119.31,36.71 119.25,36.56 119.31,36.41 119.31,35.12 119.3,35.11 119.3,34.37 119.35,34.32 119.35,33.69 119.25,33.59 118.61,33.59 118.46,33.74 118.46,34.37 118.51,34.42 118.63,34.42 118.72,34.33 119.06,34.33 119.13,34.4 119.13,35.38 119.13,35.38 119.13,36.75 119.13,36.75 119.13,37.04 119.13,37.04 119.13,37.36 119.13,37.37 119.13,37.6 119.11,37.63 119.11,37.84 119.16,37.89 119.25,37.89
GND on TOP (solid shape): 116.73,38.01 116.73,37.81 116.72,37.79 116.72,37.1 116.69,37.06 116.52,37.06 116.42,36.97 116.42,34.67 116.81,34.28 116.81,34.18 116.75,34.11 116.01,34.11 115.86,34.26 115.86,34.36 116.19,34.69 116.2,34.69 116.2,36.98 116.15,37.03 115.96,37.03 115.89,37.09 115.89,37.43 115.92,37.46 115.92,37.69 115.89,37.72 115.89,37.93 115.89,37.93 115.89,37.98 115.92,38.01 116.04,38.01 116.09,37.96 116.09,37.71 116.06,37.68 116.06,37.43 116.09,37.4 116.09,37.35 116.15,37.29 116.43,37.29 116.52,37.38 116.52,37.42 116.55,37.45 116.55,37.68 116.52,37.7 116.52,37.92 116.53,37.92 116.53,37.98 116.58,38.03 116.7,38.03
GND on TOP (solid shape): 181.25,40.1 181.25,36.95 181.1,36.79 180.51,36.79 180.28,36.57 180.28,35.14 180.69,34.73 181.01,34.55 181.33,34.71 181.5,34.71 181.73,34.94 182.65,34.94 182.9,34.69 182.9,32.5 182.79,32.39 180.45,32.39 179.8,33.04 179.8,33.54 179.42,33.92 176.85,33.92 176.22,33.29 176.22,32.76 175.83,32.36 173.51,32.36 172.99,32.88 172.99,34.79 173.35,35.14 175.28,35.14 175.84,35.7 175.84,38.85 176.04,39.06 176.5,39.06 176.78,39.33 176.78,40.33 177.15,40.69 180.65,40.69
GND on TOP (solid shape): 266.06,22.71 266.06,22.46 265.93,22.33 265.55,22.33 265.48,22.27 265.45,22.28 265.4,22.29 265.34,22.3 265,21.98 265.33,21.66 265.4,21.63 265.42,21.56 265.42,19.92 265.42,19.27 265.93,18.76 265.93,15.48 265.04,14.59 261.74,14.59 260.72,15.6 260.72,19.05 262.36,20.69 262.36,22.49 262.71,22.84 265.93,22.84
GND on TOP (solid shape): 193.38,28.87 193.38,26.91 192.28,25.81 189.77,25.81 189.75,25.82 189.73,25.83 189.71,25.85 189.69,25.88 189.65,25.96 189.7,26.04 189.77,26.51 189.3,26.53 189.19,26.5 189.12,26.6 189.12,27.78 190.85,29.51 192.74,29.51
GND on TOP (solid shape): 269.57,16.94 269.68,16.81 269.83,16.74 270.04,16.53 270.04,15.02 270.79,14.05 271.92,14.51 274.79,14.51 274.79,13.23 274.62,13.06 270.17,13.06 269.75,13.48 269.22,14.17 269.03,15.02 269.03,15.3 269.32,15.91 269.01,16.52 268.9,16.59 268.78,16.63 268.78,16.76 269.12,17.09 269.41,17.09
GND on TOP (solid shape): 177.89,61.06 176.84,61.06 176.84,60.48 174.95,60.48 174.95,61.06 173.84,61.06 173.84,60.48 173.2,60.48 172.81,60.09 172.81,55.24 170.65,53.08 167.32,53.08 165.44,54.97 165.44,56.75 165.05,57.14 165.04,57.14 161.71,60.48 122.18,60.48 119.9,58.2 111.68,58.2 109.4,60.48 68.03,60.48 66.8,59.25 66.8,55.14 64.39,52.73 61.15,52.73 58.69,55.19 58.69,59.93 58.14,60.48 32.63,60.48 32.32,60.17 32.32,54.34 34.79,54.34 34.89,54.39 35.18,54.5 35.48,54.56 36.28,54.48 36.97,54.08 36.97,53.92 36.49,53.44 36.15,53.44 35.61,53.55 35.1,53.33 31.63,53.33 31.63,53.33 31.31,53.33 31.31,54.06 22.6,54.06 22.25,54.2 22.11,54.55 22.11,54.85 22.11,54.85 22.11,61 22.25,61.35 22.6,61.49 177.89,61.49
GND on TOP (solid shape): outline of 129 points within 108.16,39.13 114.91,45.51
GND on TOP (solid shape): 107.42,20.04 107.93,20.01 108.02,20.01 108.04,19.98 108.18,19.93 108.32,19.87 108.34,19.84 108.34,19.8 108.43,19.45 108.79,19.46 108.83,19.47 108.87,19.45 108.94,19.36 109.01,19.27 109.3,19.27 109.56,19.53 109.56,19.87 109.72,20.02 109.99,20.02 110.14,19.88 110.14,19.13 111.39,17.88 111.39,17.23 111.27,17.12 110.35,17.12 110.16,17.3 110.16,17.46 109.88,17.74 109.21,17.74 106.67,16.79 106.25,19.47 106.32,19.51 106.4,19.48 106.76,19.45 106.87,19.8 106.87,19.88 106.93,19.93
GND on TOP (solid shape): outline of 173 points within 173.7,42.75 192.46,50.65
GND on TOP (solid shape): 269.68,30.58 270.01,30.58 270.04,30.54 270.04,29.02 270.79,28.05 271.92,28.51 274.79,28.51 274.79,24.49 271.92,24.49 270.79,24.95 270.04,23.98 270.04,22.58 269.37,21.91 269.03,21.91 269.03,22.42 269.24,22.69 269.32,23.02 269.32,23.18 269.28,23.41 269.18,23.61 269.17,23.63 268.63,23.94 268.03,23.74 266.39,23.74 266.08,24.05 266.08,24.89 267.28,26.09 267.3,26.09 267.51,26.33 267.41,26.64 267.38,26.72 267.41,26.79 267.39,27.29 266.91,27.16 266.91,27.15 266.53,26.78 262.63,26.78 262.56,26.85 262.56,27.8 263.04,28.28 264.24,28.28 265.04,29.08 267.94,29.08 268.1,29.24 268.15,29.24 268.77,29.16 269.25,29.57 269.31,29.76 269.32,29.96 269.23,30.26 269.03,30.5 269.03,31.01 269.25,31.01
GND on TOP (solid shape): outline of 179 points within 120.48,35.23 126.78,39.73
GND on TOP (solid shape): outline of 214 points within 96.37,46.26 106.52,50.12
GND on TOP (solid shape): 271.4,45.99 271.75,45.85 271.89,45.5 271.89,45.28 271.88,45.28 271.66,45.06 271.17,45.06 269.22,43.69 271.36,42.64 271.81,42.64 271.89,42.57 271.89,39.99 274.79,39.99 274.79,38.49 271.92,38.49 270.79,38.95 270.04,37.98 270.04,36.53 269.94,36.43 269.75,36.43 269.28,35.95 268.95,35.95 268.77,36.13 268.77,36.29 269.15,36.54 269.32,36.95 269.32,37.02 269.32,37.18 269.08,37.73 268.52,37.94 268.45,38.02 266.09,38.02 265.88,37.8 264.29,37.8 263.45,38.64 257.82,38.64 257.42,38.24 257.42,36.48 248.42,36.48 248.42,29.28 245.63,29.28 242.54,26.19 240.79,26.19 237.71,29.28 205.09,29.28 204.07,30.3 204.07,30.57 204.25,30.73 204.39,30.93 204.89,30.93 205.57,30.78 206.16,31.16 208.99,31.16 208.99,30.29 247.41,30.29 247.41,35.83 247.41,35.83 247.41,36 247.54,36.61 247.91,37.12 248.37,37.39 248.9,37.49 249.42,37.49 249.42,37.49 256.41,37.49 256.41,41 256.55,41.35 256.9,41.49 264.91,41.49 264.91,45.5 265.05,45.85 265.4,45.99
GND on TOP (solid shape): outline of 315 points within 248.93,14.26 259.71,35.97
GND on TOP (solid shape): outline of 377 points within 193.34,40.93 200.81,51.19
GND on TOP (solid shape): outline of 396 points within 0.51,0.51 271.16,30.97
GND on TOP (solid shape): outline of 949 points within 131.08,13.19 186.61,55.72
GND on TOP (solid shape): outline of 1723 points within 2.58,7.15 50.5,31.25
GND on BOTTOM (solid shape): 80.61,29.02 80.61,28.23 80.51,28.13 78.32,28.13 77.79,28.66 77.79,29.05 77.85,29.1 80.54,29.1
GND on BOTTOM (solid shape): 83.46,20.89 83.46,19.17 83.36,19.07 82.75,19.07 82.67,19.14 82.67,21 82.75,21.07 83.28,21.07
GND on BOTTOM (solid shape): 107.11,42.45 107.11,37.79 107.02,37.7 106.37,37.7 106.22,37.85 106.22,42.22 106.47,42.48 107.08,42.48
GND on BOTTOM (solid shape): 113.89,41.41 113.89,39.63 113.81,39.56 113.72,39.56 113.25,40.02 113.25,41.38 113.33,41.46 113.84,41.46
GND on BOTTOM (solid shape): 154.96,58.1 154.96,53.32 154.76,53.12 153.46,53.12 153.28,53.3 153.28,58.07 153.51,58.3 154.76,58.3
GND on BOTTOM (solid shape): 163.83,31.59 163.83,31.08 163.74,30.99 162.64,30.99 162.49,31.13 162.49,31.58 162.69,31.77 163.65,31.77
GND on BOTTOM (solid shape): 192.48,23.82 192.48,21.3 192.43,21.25 191.56,21.25 191.51,21.3 191.51,23.82 191.54,23.84 192.45,23.84
GND on BOTTOM (solid shape): 254.88,17.56 254.88,17.16 254.12,16.39 252.66,16.39 252.54,16.51 252.54,17.03 253.14,17.62 254.82,17.62
GND on BOTTOM (solid shape): 257.04,15.35 257.04,14.47 256.89,14.32 253.23,14.32 253.16,14.39 253.16,15.19 253.41,15.45 256.94,15.45
GND on BOTTOM (solid shape): 119.81,45.52 119.81,39.02 119.76,38.97 119.45,38.97 119.4,39.01 119.4,45.54 119.48,45.62 119.71,45.62
GND on BOTTOM (solid shape): 52.85,59.76 52.85,53.45 50.06,50.65 45.69,50.65 44.67,51.67 44.67,55.71 46.6,57.64 46.6,59.68 46.9,59.97 52.64,59.97
GND on BOTTOM (solid shape): 57.47,33.33 57.47,32.09 57.25,31.86 54.54,31.86 54.32,32.08 54.32,32.89 54.33,32.89 54.33,33.36 54.45,33.48 57.32,33.48
GND on BOTTOM (solid shape): 60.68,21.73 60.68,21.05 61.01,20.72 61.01,20.44 60.8,20.23 59.76,20.23 59.65,20.34 59.65,21.7 59.82,21.86 60.55,21.86
GND on BOTTOM (solid shape): 63.75,41.09 63.75,38.32 63.6,38.17 60.42,38.17 60.24,38.34 60.24,39.13 60.75,39.64 60.75,41.09 61.03,41.37 63.47,41.37
GND on BOTTOM (solid shape): 81.05,58.11 81.05,56.15 80.84,55.95 80.84,54.75 79.62,54.75 79.45,54.93 79.45,58.16 79.57,58.28 80.87,58.28
GND on BOTTOM (solid shape): 92.02,50.64 92.02,48.3 91.92,48.2 90.7,48.2 90.52,48.38 90.52,50.33 90.6,50.41 90.95,50.41 91.28,50.74 91.92,50.74
GND on BOTTOM (solid shape): 97.02,25.03 97.02,18.93 96.88,18.79 94.81,18.79 94.48,19.12 94.48,23.76 95.96,25.23 96.82,25.23
GND on BOTTOM (solid shape): 99.18,14.18 99.18,10.5 98.83,10.14 97.61,10.14 97.4,10.35 97.4,14.28 97.48,14.36 99,14.36
GND on BOTTOM (solid shape): 111.07,39.56 111.07,37.55 110.86,37.35 109.62,37.35 109.37,37.09 109.04,37.09 108.96,37.17 108.96,39.43 109.16,39.63 110.99,39.63
GND on BOTTOM (solid shape): 163.93,33.37 163.93,32.19 163.79,32.05 162.47,32.05 162.23,32.29 162.23,33.45 162.33,33.56 163.74,33.56
GND on BOTTOM (solid shape): 180.13,31.13 180.13,30.14 179.9,29.91 178.68,29.91 178.57,30.03 178.57,30.67 178.38,30.86 178.38,31.23 178.48,31.33 179.93,31.33
GND on BOTTOM (solid shape): 101.64,49.41 101.64,47.1 101.19,46.64 98.17,46.64 98.01,46.8 98.01,49.29 98.23,49.51 101.54,49.51
GND on BOTTOM (solid shape): 135.3,22.64 135.3,12.68 135.2,12.58 133.19,12.58 132.99,12.78 132.99,13.47 133.42,13.9 133.42,22.74 133.6,22.92 135.02,22.92
GND on BOTTOM (solid shape): 159.96,52.39 159.96,51.83 159.71,51.58 156.45,51.58 156.2,51.83 156.2,52.36 156.53,52.69 159.66,52.69
GND on BOTTOM (solid shape): 187.85,38.79 189.53,38.79 189.73,38.59 189.73,36.18 189.53,35.97 186.2,35.97 186,36.18 186,38.87 186.2,39.07 187.57,39.07
GND on BOTTOM (solid shape): 49.52,34.96 49.52,32.14 49.02,31.63 49.02,31.43 48.71,31.12 48,31.12 47.59,31.53 47.59,33.87 48.61,34.88 48.61,34.91 48.86,35.16 49.32,35.16
GND on BOTTOM (solid shape): 76.4,53.33 76.4,51.6 76.17,51.37 75.31,51.37 74.92,51.76 74.92,52.69 75.05,52.82 75.59,52.82 75.74,52.97 75.74,53.33 75.89,53.48 76.25,53.48
GND on BOTTOM (solid shape): 90.01,45.58 90.01,44.62 89.91,44.52 87.18,44.52 87.04,44.66 87.04,44.89 87.14,44.99 87.74,44.99 88.41,45.66 89.94,45.66
GND on BOTTOM (solid shape): 77.85,13.02 77.85,11.82 77.68,11.65 76.65,11.65 75.97,12.33 75.96,12.33 75.94,12.35 74.75,12.35 74.55,12.55 74.54,12.55 74.54,13.02 74.7,13.17 77.69,13.17
GND on BOTTOM (solid shape): 86.58,51.48 86.58,50.54 86.41,50.36 85.87,50.36 85.8,50.43 85.8,50.92 85.75,50.92 85.64,51.02 80.03,51.02 79.6,51.45 79.6,51.96 79.88,52.24 85.82,52.24
GND on BOTTOM (solid shape): 118.31,46.44 118.31,39.07 118.23,38.99 117.55,38.99 117.45,39.09 117.45,45.55 117.7,45.8 117.7,46.39 117.82,46.51 118.23,46.51
GND on BOTTOM (solid shape): 125.54,9.45 125.54,8 125.38,7.84 101.24,7.84 100.93,8.14 100.93,9.39 101.01,9.46 103.6,9.46 103.65,9.51 122.7,9.51 122.78,9.59 125.4,9.59
GND on BOTTOM (solid shape): 129.48,45.65 129.48,44.74 129.35,44.6 126.67,44.6 126.59,44.69 126.59,45.27 127.14,45.82 129.31,45.82
GND on BOTTOM (solid shape): 178.26,30.72 178.26,30.3 178.11,30.15 177.79,30.15 177.67,30.27 176.85,30.27 176.57,29.99 176.29,29.99 176.09,30.19 176.09,31.07 176.36,31.33 177.64,31.33
GND on BOTTOM (solid shape): 73.43,20.26 73.43,18.13 73.45,18.1 73.45,13.76 73.22,13.53 72.95,13.53 71.88,14.6 71.88,17.47 71.72,17.62 71.72,19.45 71.37,19.8 71.37,20.54 71.44,20.61 73.07,20.61
GND on BOTTOM (solid shape): 53.64,36.2 53.64,35.66 54.39,34.92 54.39,34.46 54.17,34.24 53.64,34.24 53.6,34.21 52.79,34.21 52.5,34.49 52.5,35.48 52.5,35.49 52.5,36.18 52.62,36.3 53.54,36.3
GND on BOTTOM (solid shape): 157.37,42.48 157.37,36.28 157.63,36.02 157.63,28.13 157.12,27.62 156.08,27.62 155.98,27.71 155.98,35.32 155.98,35.32 155.98,41.6 156.1,41.72 156.1,43 156.17,43.07 156.78,43.07
GND on BOTTOM (solid shape): 186.68,49.57 186.68,48.73 187.52,47.9 187.52,47.15 187.37,47 182.19,47 181.73,46.54 181.27,46.54 181.2,46.62 181.2,50.3 181.51,50.61 185.64,50.61
GND on BOTTOM (solid shape): 50.74,40.88 50.74,40.37 50.95,40.16 51.45,40.16 51.56,40.06 51.56,38.54 51.05,38.03 51.05,36.89 50.91,36.75 49.91,36.75 49.63,37.04 49.63,40.98 49.73,41.08 50.54,41.08
GND on BOTTOM (solid shape): 88.26,18.4 88.26,14.52 88.72,14.06 91.92,14.06 92.18,13.81 92.18,8.75 91.93,8.51 90.75,8.51 90.51,8.75 90.51,9.95 86.61,13.86 86.61,18.43 86.86,18.68 87.98,18.68
GND on BOTTOM (solid shape): 168.57,39.12 168.57,38.66 168.93,38.3 170.55,38.3 170.77,38.08 170.77,35.95 170.5,35.68 164.53,35.68 164.4,35.82 164.4,37.12 164.42,37.5 164.4,37.88 164.4,39.22 164.55,39.37 168.32,39.37
GND on BOTTOM (solid shape): 73.91,25.82 74.44,25.82 74.53,25.92 76.86,25.92 76.91,25.87 76.91,24.81 76.63,24.53 76.07,24.53 75.89,24.35 75.89,23.18 75.69,22.98 72.61,22.98 72.28,23.31 72.28,24.32 72.16,24.45 71.04,24.45 70.86,24.63 70.86,25.75 71.04,25.92 73.81,25.92
GND on BOTTOM (solid shape): 121.58,47.79 121.77,47.79 121.86,47.7 121.9,47.66 121.94,47.63 121.96,47.62 121.97,47.59 121.97,47.51 121.88,47.42 118.66,47.42 118.41,47.18 117.42,47.18 117.37,47.23 117.37,47.43 117.42,47.48 117.82,47.48 117.9,47.56 117.9,48.24 117.98,48.32 121.05,48.32
GND on BOTTOM (solid shape): 161.01,25.98 161.01,23.97 160.9,23.86 160.9,22.71 160.42,22.23 160.42,20.66 160.24,20.48 159.74,20.48 159.58,20.64 159.58,22.59 159.87,22.88 159.87,23.86 160.7,24.68 160.69,24.69 160.69,25.99 160.75,26.05 160.94,26.05
GND on BOTTOM (solid shape): 64.49,49.04 64.49,48.73 64.13,48.38 63.91,48.38 63.6,48.55 63.28,48.38 62.12,48.38 61.84,48.66 61.84,48.96 61.89,49.01 63.9,49.01 64.05,49.16 64.36,49.16
GND on BOTTOM (solid shape): 107.11,46.13 107.11,45.12 106.95,44.97 104.54,44.97 104.52,44.97 104.5,44.98 104.34,45.08 104.12,45.07 104.1,45.08 103.96,45.22 103.96,45.85 104.08,45.98 106.57,45.98 106.83,46.24 107,46.24
GND on BOTTOM (solid shape): 37,51.83 37.54,51.83 37.99,51.38 37.99,49.59 37.84,49.44 37.3,49.44 36.91,49.83 36.63,49.91 36.36,49.82 36.26,49.81 36.2,49.9 36.2,51.72 36.34,51.85 36.98,51.85
GND on BOTTOM (solid shape): 85.08,58.8 85.08,57.83 84.91,57.65 84.91,56.72 84.89,56.5 84.91,56.28 84.91,55.74 84.78,55.62 81.53,55.62 81.36,55.78 81.34,55.83 81.29,55.87 81.27,55.91 81.27,57.8 81.4,57.93 82.44,57.93 82.6,58.08 82.6,58.75 82.71,58.86 85.02,58.86
GND on BOTTOM (solid shape): 112.98,46.6 112.98,44.93 113.22,44.68 113.67,44.68 113.76,44.59 113.76,44.3 113.68,44.23 113.1,44.23 113,44.13 113,42.96 112.92,42.88 112.44,42.88 112.36,42.81 112.36,39.91 112.22,39.76 112.22,39.05 112.21,39.01 112.17,39 111.8,39 111.7,39.1 111.7,40.39 112.03,40.72 112.03,43.42 112.31,43.7 112.31,46.6 112.37,46.66 112.91,46.66
GND on BOTTOM (solid shape): 37.32,33.25 37.78,33.25 37.85,33.18 37.85,32.39 37.78,32.31 37.69,32.31 37.31,32.3 36.95,32.17 36.81,32.08 36.69,31.96 36.6,31.94 36.53,32 36.4,32.23 36.2,32.4 36.2,33.58 36.43,33.8 36.78,33.8
GND on BOTTOM (solid shape): 79.45,46.32 79.45,43.75 78.68,42.99 78.68,42.41 78.53,42.26 77.54,42.26 77.29,42.51 77.29,43.54 77.31,43.57 77.33,43.57 77.76,43.89 77.8,44.43 77.79,44.44 77.79,44.87 78.47,45.55 78.47,45.87 78.47,45.88 78.5,46.06 78.47,46.24 78.47,46.24 78.47,46.33 78.66,46.53 79.23,46.53
GND on BOTTOM (solid shape): 114.42,58.51 114.42,52.03 114.31,51.92 114.04,51.92 113.91,51.8 113.91,48.93 113.86,48.88 111.47,48.88 111.22,48.62 111.22,47.51 111.28,47.45 112.66,47.45 112.77,47.34 112.77,46.94 112.66,46.83 111.91,46.83 111.72,46.64 110.64,46.64 110.59,46.69 110.59,47.25 110.2,47.63 110.2,49.06 110.35,49.21 110.35,50.05 109.21,51.19 109.21,51.26 110,52.05 110.38,52.05 110.61,51.82 111.25,51.82 111.5,52.08 111.5,54.06 112.72,55.27 112.72,55.63 112.87,55.79 112.87,58.42 113.04,58.59 114.34,58.59
GND on BOTTOM (solid shape): 116.64,46.76 116.64,45.85 116.58,45.8 116.41,45.8 116.23,45.62 116.23,42.59 116.15,42.51 116.15,42.12 115.72,41.68 115.72,40.52 115.79,40.44 116.61,40.44 116.68,40.37 116.68,39.38 116.61,39.3 116.28,39.3 116.15,39.17 116.15,38.82 116.07,38.74 115.92,38.74 115.34,39.33 115.34,43.13 115.28,43.18 114.93,43.18 114.91,43.21 114.91,43.41 114.93,43.44 115.31,43.44 115.62,43.74 115.62,44.41 115.57,44.46 114.52,44.46 114.45,44.53 114.45,44.76 114.5,44.81 115.46,44.81 115.56,44.91 115.56,45.53 115.62,45.59 115.62,46.62 115.84,46.84 116.56,46.84
GND on BOTTOM (solid shape): 88.09,9.15 88.09,4.67 90.09,4.67 90.09,3.52 104.94,3.52 105.42,4 129.58,4 130.09,3.49 130.09,1.52 216.28,1.52 216.28,3.15 216.36,3.23 217.18,3.23 217.29,3.13 217.29,1.49 223.04,1.49 223.04,0.51 129.57,0.51 129.22,0.65 129.08,1 129.08,3.51 106.36,3.51 105.36,2.51 89.57,2.51 89.22,2.65 89.08,3 89.08,3.66 87.08,3.66 87.08,9.2 87.12,9.24 88.01,9.24
GND on BOTTOM (solid shape): 100.8,34.78 100.99,34.72 101.17,34.78 104.52,34.78 104.74,34.56 104.74,33.57 104.63,33.33 104.74,33.09 104.74,32.83 104.51,32.61 104.24,32.61 103.89,32.69 103.69,32.39 103.69,32.37 103.55,32.23 103.31,32.23 103.19,32.11 103.19,31.93 103.19,31.93 103.19,31.68 103.02,31.51 102.42,31.51 102.08,31.17 100.4,31.17 100.3,31.27 100.3,34.68 100.4,34.78
GND on BOTTOM (solid shape): 138.42,53.68 139.62,53.68 139.93,52.57 141.07,52.43 142.34,51.16 142.34,50.02 142.24,49.93 140.53,49.93 140.52,49.92 137.44,49.92 137.18,50.19 137.18,52.13 136.77,52.53 127.88,52.53 127.32,53.09 127.32,54.49 127.6,54.77 129.55,54.77 129.59,54.81 129.93,54.81 129.94,54.81 130.08,54.78 130.22,54.81 130.23,54.81 130.8,54.81 131.26,55.28 136.82,55.28
GND on BOTTOM (solid shape): 156.08,20.02 156.71,19.39 157.35,20.02 157.35,20.28 157.86,20.28 158.05,20.09 158.05,19.85 158.05,19.52 158.06,19.52 158.06,19.22 158.04,19.19 158.04,19.18 157.94,18.96 158.04,18.73 158.04,18.72 158.06,18.69 158.06,17.06 158.02,17.03 158.02,15.83 157.44,15.25 156.05,15.25 155.93,15.37 155.93,20.21 156,20.28 156.08,20.28
GND on BOTTOM (solid shape): 232.19,9.96 232.19,8.39 232.27,8.31 232.27,1.52 261.93,1.52 261.93,2.23 265.94,2.23 266.68,2.97 268.87,2.97 270.49,1.36 270.49,0.51 269.28,0.51 267.6,1.76 265.91,0.51 231.26,0.51 231.26,9.02 223.04,9.02 223.04,7.76 217.29,7.76 217.29,6.05 217.23,5.98 216.37,5.98 216.28,6.08 216.28,8.77 222.03,8.77 222.03,10.03 232.12,10.03
GND on BOTTOM (solid shape): 180.77,51.37 180.77,44.62 181.78,43.6 181.78,36.54 181.02,35.78 181.02,35.17 181.55,34.64 181.55,34.18 181.25,33.87 175.1,33.87 174.75,34.23 174.75,40.43 175.82,40.43 175.83,40.37 175.84,40.32 175.86,40.27 175.89,40.22 175.92,40.18 175.96,40.14 176,40.11 176.05,40.09 176.1,40.07 176.15,40.06 176.21,40.06 176.26,40.06 176.31,40.08 176.36,40.1 176.41,40.13 176.45,40.16 176.49,40.2 176.52,40.25 176.54,40.29 176.56,40.35 176.56,40.4 176.56,40.45 176.56,40.51 176.54,40.56 176.52,40.61 176.49,40.65 176.45,40.69 176.41,40.73 176.36,40.76 176.31,40.78 176.26,40.79 176.21,40.8 176.15,40.79 176.1,40.78 176.05,40.77 176,40.74 175.96,40.71 175.92,40.67 175.89,40.63 175.86,40.58 175.84,40.53 175.83,40.48 175.82,40.43 174.75,40.43 174.75,47.81 174.35,48.21 169.33,48.21 169.32,48.21 167.23,48.21 165.11,48.21 164.87,48.46 164.87,51.49 165.15,51.77 180.37,51.77
GND on BOTTOM (solid shape): 270.04,16.24 270.04,15.02 270.79,14.05 271.92,14.51 274.79,14.51 274.79,12.96 269.25,12.96 268.43,13.78 268.43,15.14 269.32,15.9 268.43,16.66 268.43,16.87 268.61,17.06 269.23,17.06
GND on BOTTOM (solid shape): 35.1,30.96 35.62,30.74 36.18,30.87 36.19,30.88 36.37,30.88 36.4,30.85 36.4,30.84 36.54,30.53 36.76,30.27 36.77,30.25 36.77,30.06 36.15,29.78 35.48,29.74 35.18,29.8 34.89,29.9 34.79,29.95 32.32,29.95 32.32,24.08 2.47,24.08 2.14,23.75 2.14,17.46 1.52,16.84 1.52,9.32 7.47,9.32 7.47,6.69 6.46,6.69 6.46,8.31 0.51,8.31 0.51,24.6 0.65,24.95 1,25.09 31.31,25.09 31.31,30.96
GND on BOTTOM (solid shape): 124.56,46.39 124.56,46.03 124.45,45.93 123.23,45.93 123.03,45.72 120.98,45.72 120.83,45.57 120.83,45.06 120.88,45.01 123.01,45.01 123.06,45.06 123.85,45.06 123.95,44.96 123.95,44.72 123.9,44.67 122.87,44.67 122.86,44.66 120.95,44.66 120.83,44.53 120.83,43.92 120.88,43.87 123.04,43.87 123.04,43.87 123.82,43.87 123.9,43.79 123.9,43.54 123.87,43.51 120.88,43.51 120.75,43.39 120.75,42.83 121.91,42.83 121.96,42.78 121.96,42.45 121.93,42.42 120.93,42.42 120.75,42.24 120.75,41.81 120.93,41.63 120.95,41.66 126.16,41.66 126.23,41.59 126.23,40.88 126.18,40.83 125.34,40.83 124.92,41.25 120.9,41.25 120.78,41.12 120.78,40.57 120.85,40.49 121.89,40.49 121.92,40.46 121.92,40.26 121.89,40.24 120.88,40.24 120.78,40.13 120.78,39.47 120.85,39.4 122.17,39.4 122.68,39.9 122.68,40.47 122.78,40.57 123.64,40.57 123.72,40.49 123.72,39.44 123.27,39 120.55,39 120.42,39.13 120.42,39.29 120.42,39.3 120.42,45.9 120.98,46.46 124.48,46.46
GND on BOTTOM (solid shape): 74.97,11.2 74.97,9.61 70.81,9.61 70.81,3.66 68.81,3.66 68.81,1 68.67,0.65 68.32,0.51 47.35,0.51 47,0.65 46.86,1 46.86,3.51 14.64,3.51 14.64,1 14.5,0.65 14.15,0.51 1,0.51 0.65,0.65 0.51,1 0.51,2.04 6.46,2.04 6.46,3.66 7.47,3.66 7.47,1.52 13.63,1.52 13.63,4.52 17.42,4.52 18.33,5.43 18.33,7.56 18.4,7.63 18.41,7.63 19.09,8.31 39.84,8.31 40.07,8.54 40.07,9.21 40.07,9.21 40.07,9.43 40.15,9.51 40.56,9.51 40.58,9.49 40.58,7.78 40.73,7.63 43.83,7.63 43.93,7.53 43.93,5.27 44.68,4.52 47.87,4.52 47.87,1.52 67.8,1.52 67.8,7.87 69.8,9.87 69.8,10.62 70.45,11.27 74.9,11.27
GND on BOTTOM (solid shape): 177.89,58.49 183.91,58.49 183.91,61.49 190.64,61.49 190.64,58.49 197.16,58.49 197.16,61.49 208.5,61.49 208.85,61.35 208.99,61 208.99,58.51 202.99,58.51 202.99,55.69 208.99,55.69 208.99,54.68 201.98,54.68 201.98,60.48 198.17,60.48 198.17,57.48 189.63,57.48 189.63,60.48 184.92,60.48 184.92,57.48 176.88,57.48 176.88,60.48 173.81,60.48 172.19,58.86 172.19,55.51 170.39,53.71 167.69,53.71 165.69,55.71 165.69,58.57 163.78,60.48 67.29,60.48 65.86,59.05 65.86,55.53 64.06,53.73 61.55,53.73 59.7,55.57 59.7,58.92 58.14,60.48 39.77,60.48 39.77,60.87 39.13,60.87 38.88,61.11 36.92,61.11 36.67,60.87 36.03,60.87 36.03,60.48 33.04,60.48 32.32,59.76 32.32,54.34 34.79,54.34 34.89,54.39 35.18,54.5 35.48,54.56 36.3,54.47 37.01,54.05 37.01,53.91 36.99,53.89 36.75,53.64 36.63,53.31 36.62,53.27 36.36,53.27 36.35,53.28 35.73,53.56 35.1,53.33 31.91,53.33 31.91,53.33 31.31,53.33 31.31,54.06 30.5,54.06 30.5,61.49 177.89,61.49
GND on BOTTOM (solid shape): 43.55,12.2 43.55,11.9 43.46,11.81 42.27,11.81 42.18,11.89 42.18,12.63 42.11,12.71 41.8,12.71 41.7,12.61 41.7,11.91 41.6,11.81 40.39,11.81 40.32,11.84 40.29,11.91 40.1,12.09 39.91,11.9 39.91,11.88 39.83,11.81 38.43,11.81 38.42,11.83 38.25,11.94 38.08,11.83 38.06,11.81 35.77,11.81 35.77,11.86 35.58,12.04 35.39,11.86 35.39,11.84 35.36,11.81 32.29,11.81 32.22,11.83 32.19,11.9 32,12.07 31.81,11.9 31.78,11.83 31.71,11.81 27.75,11.81 27.74,11.86 27.55,12.04 27.36,11.86 27.36,11.84 27.33,11.81 22.5,11.81 22.36,11.95 22.36,12.31 22.5,12.45 26,12.45 26.01,12.45 26.11,12.45 26.9,13.24 42.51,13.24
GND on BOTTOM (solid shape): 270.04,30.17 270.04,29.1 270.04,29.1 270.04,28.96 270.82,28.04 271.92,28.51 274.79,28.51 274.79,24.49 271.92,24.49 270.79,24.95 270.04,23.98 270.04,22.69 269.24,21.89 268.81,21.89 268.64,22.06 268.64,22.26 269.12,22.51 269.32,23.02 269.32,23.18 268.94,23.84 268.18,23.85 268.08,23.79 268,23.71 267.98,23.69 267.94,23.69 267.81,23.82 267.81,24.88 267.96,25.03 267.96,27.97 267.81,28.12 267.81,29.13 267.93,29.25 268.14,29.25 268.15,29.24 268.55,29.13 268.95,29.24 268.96,29.25 269.03,29.25 269.03,29.3 269.05,29.31 269.27,30.16 268.57,30.67 268.53,30.68 268.52,30.72 268.52,30.78 268.76,31.02 269.19,31.02
GND on BOTTOM (solid shape): outline of 203 points within 119.32,35.22 136.01,37.85
GND on BOTTOM (solid shape): 271.38,45.99 271.74,45.82 271.89,45.45 271.89,44.69 271.82,44.59 271.71,44.63 269.22,43.8 271.71,42.97 271.82,43.01 271.89,42.91 271.89,39.99 274.79,39.99 274.79,38.49 271.92,38.49 270.79,38.95 270.04,37.98 270.04,36.63 269.47,36.06 268.82,36.06 268.75,36.13 268.75,36.28 269.16,36.56 269.32,37.02 269.32,37.18 269.24,37.51 269.03,37.78 268.47,37.94 267.96,37.67 263.62,37.67 261.23,40.06 258.96,40.06 257.42,38.52 257.42,36.48 248.42,36.48 248.42,29.28 207.98,29.28 207.98,30.15 206.59,30.15 206.47,30.07 205.74,29.78 204.97,29.81 204.25,30.53 204.25,30.72 204.26,30.74 204.4,30.95 204.48,31.19 204.48,31.23 204.62,31.23 204.63,31.2 205.39,30.76 206.16,31.16 208.99,31.16 208.99,30.29 247.41,30.29 247.41,35.78 247.41,35.78 247.41,36 247.47,36.41 247.64,36.79 247.7,36.89 247.78,36.99 247.82,37.03 248.31,37.37 248.9,37.49 249.35,37.49 249.35,37.49 249.71,37.49 249.71,36.73 250.87,36.73 250.87,37.49 250.94,37.49 250.94,37.49 256.41,37.49 256.41,41.49 264.91,41.49 264.91,45.99
GND on IN1 (solid shape): 180.49,40.41 180.49,34.11 180.21,33.83 176.93,33.83 176.66,34.1 176.66,40.42 176.91,40.68 180.22,40.68
GND on IN1 (solid shape): 102.3,34.63 102.3,33.6 102.3,31.3 102.24,31.24 102.23,31.23 102.21,31.22 100.38,31.22 100.3,31.3 100.3,34.45 100.48,34.63 100.68,34.63 100.83,34.78 102.15,34.78
GND on IN1 (solid shape): 112.93,53.2 112.93,51.48 112.27,50.82 111.92,50.82 111,49.9 111,49.32 110.98,49.3 110.76,49.08 110.66,49.08 110.59,49 110.36,49 110.04,49.32 110.04,50.26 109.29,51.01 109.29,51.65 110.95,53.31 112.82,53.31
GND on IN1 (solid shape): 130.15,36.89 130.15,36.51 130.23,36.43 130.23,36.3 130.61,35.92 130.74,35.92 130.8,35.86 130.8,35.65 130.75,35.6 130.41,35.6 130.26,35.45 128.15,35.45 127.63,35.97 127.3,35.97 127.19,35.95 127.08,35.91 127.05,35.91 126.72,36.24 126.72,36.43 126.88,36.59 127.73,36.59 128.31,37.17 129.87,37.17
GND on IN1 (solid shape): 37,51.83 37.54,51.83 37.99,51.38 37.99,49.59 37.84,49.44 37.3,49.44 36.91,49.83 36.63,49.91 36.36,49.82 36.26,49.81 36.2,49.9 36.2,51.72 36.34,51.85 36.98,51.85
GND on IN1 (solid shape): 63.91,41.01 63.91,37.41 63.66,37.16 60.53,37.16 60.17,37.52 60.17,42.02 60.27,42.12 60.6,42.12 60.73,41.98 60.97,41.8 61.11,42.07 61.12,42.16 61.2,42.21 62.71,42.21
GND on IN1 (solid shape): 37.32,33.25 37.78,33.25 37.85,33.18 37.85,32.39 37.78,32.31 37.69,32.31 37.31,32.3 36.95,32.17 36.81,32.08 36.69,31.96 36.6,31.94 36.53,32 36.4,32.23 36.2,32.4 36.2,33.58 36.43,33.8 36.78,33.8
GND on IN1 (solid shape): 270.04,16.44 270.04,15.02 270.79,14.05 271.92,14.51 274.79,14.51 274.79,12.95 269.35,12.95 268.39,13.92 268.39,15.03 268.42,15.11 268.5,15.13 269.31,15.76 268.77,16.64 268.7,16.71 268.73,16.81 268.95,17.02 269.45,17.02
GND on IN1 (solid shape): outline of 103 points within 50.06,36.28 59.81,41.03
GND on IN1 (solid shape): outline of 130 points within 115.87,37.14 124.58,38.82
GND on IN1 (solid shape): 177.89,58.49 183.91,58.49 183.91,61.49 190.64,61.49 190.64,58.49 197.16,58.49 197.16,61.49 208.5,61.49 208.85,61.35 208.99,61 208.99,58.51 202.99,58.51 202.99,55.69 208.99,55.69 208.99,54.76 208.9,54.68 201.98,54.68 201.98,60.48 198.17,60.48 198.17,57.48 189.63,57.48 189.63,60.48 184.92,60.48 184.92,57.48 176.88,57.48 176.88,60.48 173.8,60.48 172.19,58.88 172.19,55.51 170.4,53.71 167.67,53.71 165.68,55.7 165.68,58.56 163.77,60.48 67.29,60.48 65.86,59.05 65.86,55.53 64.06,53.73 61.54,53.73 59.71,55.56 59.71,58.91 58.14,60.48 23.12,60.48 23.12,55.22 32.32,55.22 32.32,54.34 34.79,54.34 34.89,54.39 35.18,54.5 35.48,54.56 36.3,54.47 37.01,54.05 37.04,53.97 37,53.89 36.96,53.87 36.92,53.83 36.71,53.56 36.62,53.23 36.54,53.14 36.43,53.18 35.8,53.55 35.1,53.33 31.58,53.33 31.58,53.33 31.31,53.33 31.31,54.06 22.6,54.06 22.25,54.2 22.11,54.55 22.11,54.79 22.11,54.79 22.11,61 22.25,61.35 22.6,61.49 177.89,61.49
GND on IN1 (solid shape): outline of 141 points within 113.94,42.75 116,46.56
GND on IN1 (solid shape): outline of 164 points within 153.41,47.7 161.14,56.74
GND on IN1 (solid shape): outline of 156 points within 96.95,46.18 108.88,50.54
GND on IN1 (solid shape): outline of 107 points within 0.51,0.51 270.49,30.96
GND on IN1 (solid shape): outline of 246 points within 31.19,55.03 54.83,59.96
GND on IN1 (solid shape): 271.4,45.99 271.75,45.85 271.89,45.5 271.89,45.23 271.7,45.04 271.22,45.04 269.22,43.64 271.48,42.73 271.79,42.73 271.89,42.63 271.89,39.99 274.79,39.99 274.79,38.49 271.92,38.49 270.79,38.95 270.04,37.98 270.04,36.72 269.23,35.91 268.84,35.91 268.74,36.01 268.74,36.28 269.16,36.55 269.32,37.02 269.32,37.18 268.88,37.87 268.07,37.78 267.5,37.78 264.8,40.48 257.42,40.48 257.42,36.48 248.42,36.48 248.42,29.28 205.09,29.28 204.12,30.25 204,30.37 203.9,30.49 204.3,30.79 204.49,31.25 204.61,31.25 205.36,30.77 206.16,31.16 208.99,31.16 208.99,30.29 247.41,30.29 247.41,35.9 247.41,35.9 247.41,36.09 247.5,36.52 247.71,36.91 248.24,37.34 248.9,37.49 249.26,37.49 249.26,37.49 256.41,37.49 256.41,41 256.55,41.35 256.9,41.49 264.91,41.49 264.91,45.5 265.05,45.85 265.4,45.99
GND on IN1 (solid shape): outline of 1076 points within 248.93,21.93 274.79,39.73
GND on IN1 (solid shape): outline of 2437 points within 38.45,33.71 84.04,59.93
GND on GND1 (solid shape): 123.87,44.93 123.87,44.73 123.84,44.71 123.59,44.71 123.57,44.73 123.48,44.73 123.39,44.75 123.31,44.73 123.23,44.73 123.11,44.61 123.11,44.53 123.09,44.48 123.09,44.42 123.08,44.4 123.02,44.35 122.81,44.35 122.69,44.47 122.69,44.59 122.55,44.73 122.47,44.73 122.4,44.74 122.27,44.73 122.13,44.59 122.13,44.47 122.07,44.4 122.05,44.4 122.02,44.39 121.91,44.36 121.81,44.39 121.78,44.4 121.74,44.4 121.7,44.44 121.7,44.59 121.54,44.76 121.27,44.76 121.24,44.74 121.16,44.71 121.09,44.74 121.06,44.76 120.99,44.76 120.98,44.76 120.9,44.78 120.81,44.76 120.73,44.72 120.67,44.66 120.63,44.67 120.6,44.69 120.59,44.74 120.57,44.75 120.54,44.84 120.57,44.92 120.59,44.94 120.59,44.95 120.61,44.97 120.64,44.98 123.82,44.98
GND on GND1 (solid shape): 123.44,44.1 123.56,44.06 123.58,44.04 123.77,44.04 123.96,43.85 123.96,43.65 123.82,43.52 123.64,43.52 123.52,43.64 123.28,43.64 123.12,43.48 123.12,43.37 123.11,43.35 123.1,43.33 123.02,43.26 123,43.26 122.98,43.25 122.9,43.24 122.83,43.25 122.78,43.27 122.77,43.28 122.67,43.37 122.67,43.41 122.67,43.53 122.55,43.64 122.27,43.64 122.13,43.5 122.13,43.37 122.12,43.35 122.11,43.33 122.02,43.26 121.82,43.26 121.75,43.32 121.68,43.5 121.56,43.62 121.48,43.62 121.41,43.63 121.28,43.62 121.25,43.59 121.13,43.59 121.06,43.64 121,43.67 120.8,43.67 120.69,43.56 120.64,43.55 120.6,43.58 120.59,43.62 120.57,43.63 120.54,43.72 120.57,43.8 120.59,43.82 120.61,43.88 120.61,43.99 120.63,44.03 120.66,44.04 121.59,44.04 121.64,44.04 121.68,44.04 122.11,44.04 122.17,44.03 122.24,44.04 123.1,44.04 123.16,44.03 123.23,44.04 123.28,44.04 123.31,44.07
GND on GND1 (solid shape): 119.39,42.61 119.47,42.6 119.51,42.53 119.6,42.39 119.76,42.37 119.84,42.36 119.89,42.3 119.89,39.44 119.57,39.13 119.55,39.13 119.47,39.19 119.49,39.22 119.52,39.25 119.52,39.28 119.54,39.31 119.6,39.4 119.61,39.64 119.44,39.8 119.42,39.81 119.38,39.86 119.36,39.9 119.31,39.97 119.27,40 119.25,40.02 119.25,40.09 119.25,40.17 119.29,40.2 119.33,40.23 119.36,40.28 119.38,40.33 119.38,40.4 119.37,40.44 119.35,40.47 119.29,40.54 119.26,40.55 119.24,40.57 119.24,40.59 119.24,40.72 119.25,40.73 119.28,40.77 119.36,40.93 119.28,41.09 119.27,41.11 119.25,41.2 119.26,41.29 119.3,41.32 119.36,41.4 119.4,41.47 119.5,41.47 119.53,41.5 119.57,41.57 119.57,41.59 119.61,41.66 119.61,41.87 119.55,41.97 119.3,42.22 119.28,42.23 119.24,42.3 119.28,42.38 119.33,42.46 119.34,42.55 119.34,42.56 119.38,42.61
GND on GND1 (solid shape): 121.57,46.44 121.59,46.41 121.78,46.21 121.98,46.41 121.99,46.44 122.03,46.46 122.18,46.46 122.22,46.44 122.23,46.41 122.43,46.21 122.62,46.41 122.62,46.43 122.65,46.46 122.82,46.46 122.86,46.44 122.88,46.41 123.07,46.21 123.26,46.41 123.28,46.44 123.31,46.46 123.47,46.46 123.51,46.44 123.58,46.27 123.72,46.21 123.8,46.19 123.83,46.12 123.83,46.09 123.84,46.06 123.83,45.97 123.74,45.93 123.31,45.93 123.2,45.84 123.12,45.74 123.12,45.64 122.98,45.5 122.89,45.49 122.85,45.5 122.73,45.5 122.67,45.56 122.67,45.71 122.53,45.85 122.4,45.86 122.27,45.85 122.1,45.69 122.1,45.61 122.04,45.55 122.01,45.53 121.85,45.5 121.72,45.58 121.72,45.59 121.68,45.64 121.65,45.7 121.65,45.74 121.51,45.88 121.27,45.88 121.24,45.86 121.17,45.83 121.09,45.86 121.06,45.88 121.05,45.88 121.03,45.9 120.91,45.91 120.81,45.9 120.76,45.88 120.73,45.86 120.68,45.82 120.64,45.8 120.6,45.83 120.58,45.87 120.57,45.88 120.54,45.93 120.54,45.98 120.54,46.01 120.57,46.06 120.62,46.09 120.65,46.1 120.99,46.44 121,46.45 121.02,46.46 121.54,46.46
GND on GND1 (solid shape): outline of 98 points within 117.52,39.12 118.96,42.62
GND on GND1 (solid shape): outline of 288 points within 117.26,42.65 119.89,46.71
GND on GND1 (solid shape): outline of 70635 points within 0.51,0.51 274.79,61.49
GND on IN2 (solid shape): 101.64,49.41 101.64,47.1 101.19,46.64 97.94,46.64 97.78,46.79 97.78,49.41 97.88,49.51 101.54,49.51
GND on IN2 (solid shape): 180.49,40.41 180.49,34.11 180.21,33.83 176.93,33.83 176.66,34.1 176.66,40.42 176.91,40.68 180.22,40.68
GND on IN2 (solid shape): 102.3,34.63 102.3,31.3 102.18,31.17 100.4,31.17 100.3,31.27 100.3,34.52 100.5,34.72 100.9,34.72 100.96,34.78 102.15,34.78
GND on IN2 (solid shape): 70.17,46.31 70.17,44.8 69.96,44.58 69.08,44.58 68.96,44.69 68.62,44.69 68.43,44.89 68.43,45.8 68.48,45.99 68.4,46.16 68.4,46.37 68.55,46.53 69.96,46.53
GND on IN2 (solid shape): 37.22,51.65 37.22,51.64 37.39,51.64 37.85,51.18 37.85,49.66 37.68,49.49 37.3,49.49 37.01,49.78 36.98,49.79 36.95,49.8 36.66,49.91 36.36,49.82 36.26,49.81 36.2,49.9 36.2,51.65 36.45,51.89 36.98,51.89
GND on IN2 (solid shape): 37.32,33.25 37.78,33.25 37.85,33.18 37.85,32.39 37.78,32.31 37.69,32.31 37.31,32.3 36.95,32.17 36.81,32.08 36.69,31.96 36.6,31.94 36.53,32 36.4,32.23 36.2,32.4 36.2,33.58 36.43,33.8 36.78,33.8
GND on IN2 (solid shape): 232.27,7.61 232.27,1.52 261.93,1.52 261.93,1.58 266.32,1.58 267.01,2.27 268.57,2.27 269.24,1.59 270.27,1.59 270.49,1.37 270.49,0.51 269.28,0.51 267.6,1.76 265.91,0.51 231.26,0.51 231.26,7.8 231.39,7.92 231.95,7.92
GND on IN2 (solid shape): 60.94,41.71 65.04,41.71 65.24,41.51 65.24,36.3 64.94,35.99 63.92,35.99 63.91,36.04 63.64,36.34 63.26,36.22 63.18,36.18 62.81,36.35 62.44,36.18 62.36,36.22 61.98,36.34 61.7,36.04 61.7,35.99 59.04,35.99 58.72,36.31 58.72,41.88 58.93,42.09 60.56,42.09
GND on IN2 (solid shape): 270.04,16.44 270.04,15.02 270.79,14.05 271.92,14.51 274.79,14.51 274.79,12.95 269.35,12.95 268.39,13.92 268.39,15.03 268.42,15.11 268.5,15.13 269.3,15.75 268.8,16.63 268.8,16.77 269.05,17.02 269.45,17.02
GND on IN2 (solid shape): 177.89,58.49 183.91,58.49 183.91,61.49 190.64,61.49 190.64,58.49 197.16,58.49 197.16,61.49 208.5,61.49 208.85,61.35 208.99,61 208.99,58.51 202.99,58.51 202.99,55.69 208.99,55.69 208.99,54.76 208.9,54.68 201.98,54.68 201.98,60.48 198.17,60.48 198.17,57.48 189.63,57.48 189.63,60.48 184.92,60.48 184.92,57.48 176.88,57.48 176.88,60.48 173.8,60.48 172.19,58.88 172.19,55.51 170.4,53.71 167.67,53.71 165.68,55.7 165.68,58.56 163.77,60.48 67.29,60.48 65.86,59.05 65.86,55.53 64.06,53.73 61.54,53.73 59.71,55.56 59.71,58.91 58.14,60.48 33.26,60.48 32.32,59.54 32.32,54.34 34.79,54.34 34.89,54.39 35.18,54.5 35.48,54.56 36.3,54.47 37.01,54.05 37.04,53.97 37,53.89 36.96,53.87 36.92,53.83 36.71,53.56 36.62,53.23 36.54,53.14 36.43,53.18 35.8,53.55 35.1,53.33 31.48,53.33 31.48,53.33 31.31,53.33 31.31,54.06 22.6,54.06 22.25,54.2 22.11,54.55 22.11,54.89 22.11,54.89 22.11,61 22.25,61.35 22.6,61.49 177.89,61.49
GND on IN2 (solid shape): outline of 180 points within 154.16,48.25 161.14,56.32
GND on IN2 (solid shape): 269.53,31.07 269.66,30.82 269.93,30.73 270.01,30.7 270.04,30.63 270.04,29.02 270.79,28.05 271.92,28.51 274.79,28.51 274.79,24.49 271.92,24.49 270.79,24.95 270.04,23.98 270.04,22.66 269.31,21.93 268.96,21.93 268.76,22.12 268.76,22.29 269.16,22.56 269.32,23.02 269.32,23.18 269.32,23.22 269.07,23.75 268.52,23.94 268.5,23.94 268.34,24.1 268.34,24.9 267.65,25.59 267.65,27.16 267.41,27.4 266.7,27.4 266.53,27.23 266.26,27.23 266.07,27.42 266.07,28.64 267.64,30.2 267.76,30.22 267.81,30.1 269.09,29.36 268.35,30.64 268.23,30.69 268.25,30.81 268.56,31.12 269.53,31.12
GND on IN2 (solid shape): outline of 93 points within 0.51,0.51 223.04,30.96
GND on IN2 (solid shape): 271.4,45.99 271.75,45.85 271.89,45.5 271.89,45.23 271.7,45.04 271.22,45.04 269.22,43.64 271.48,42.73 271.79,42.73 271.89,42.63 271.89,39.99 274.79,39.99 274.79,38.49 271.92,38.49 270.79,38.95 270.04,37.98 270.04,36.72 269.23,35.91 268.84,35.91 268.74,36.01 268.74,36.28 269.16,36.55 269.32,37.02 269.32,37.18 268.88,37.87 268.07,37.78 267.5,37.78 264.8,40.48 257.42,40.48 257.42,36.48 248.42,36.48 248.42,29.28 205.09,29.28 204.12,30.26 204,30.37 203.9,30.49 204.3,30.79 204.49,31.25 204.61,31.25 205.36,30.77 206.16,31.16 208.99,31.16 208.99,30.29 247.41,30.29 247.41,36.14 247.42,36.14 247.62,36.77 248.08,37.24 248.08,37.24 248.47,37.43 248.9,37.49 249.48,37.49 249.48,37.49 256.41,37.49 256.41,41 256.55,41.35 256.9,41.49 264.91,41.49 264.91,45.5 265.05,45.85 265.4,45.99
GND on IN2 (solid shape): outline of 228 points within 69.62,51.33 84.04,59.91
GND on SGND (solid shape): outline of 1649 points within 0.51,0.51 274.79,61.49
GND on SVCC (solid shape): 190.64,58.49 197.16,58.49 197.16,61.49 208.5,61.49 208.85,61.35 208.99,61 208.99,58.51 204,58.51 203.29,58.21 202.99,57.5 202.99,56.7 203.29,55.99 204,55.69 208.99,55.69 208.99,53.56 207.24,53.56 206.95,53.97 206.79,54.14 206.36,54.44 206.04,54.56 205.76,54.63 205.42,54.65 205.06,54.64 204.75,54.56 204.25,54.31 203.13,54.44 202.41,53.56 200.02,53.56 199.13,52.67 199.13,49.82 198.75,49.44 192.19,49.44 192.16,49.46 192.16,49.47 191.87,49.66 191.53,49.44 181.25,49.44 178.73,51.96 178.73,56.92 178.75,56.95 178.79,56.97 180.59,56.97 181.22,56.99 181.76,57.23 182.15,57.51 182.36,57.75 182.58,58.06 182.74,58.49 183.91,58.49 183.91,61.49 190.64,61.49
GND on SVCC (solid shape): outline of 176 points within 22.11,40.5 59.38,61.49
GND on SVCC (solid shape): outline of 277 points within 76.88,35.85 126.74,61.49
GND on SVCC (solid shape): outline of 415 points within 0.51,0.51 91.85,30.96
GND on SVCC (solid shape): outline of 1167 points within 98.22,0.51 274.79,45.99
GND on IN3 (solid shape): 101.64,49.41 101.64,47.1 101.19,46.64 97.94,46.64 97.78,46.79 97.78,49.41 97.88,49.51 101.54,49.51
GND on IN3 (solid shape): 102.3,34.63 102.3,31.3 102.18,31.17 100.4,31.17 100.3,31.27 100.3,34.68 100.4,34.78 102.15,34.78
GND on IN3 (solid shape): 69.61,46.17 69.92,46.17 70.1,45.99 70.1,44.82 69.94,44.67 68.6,44.67 68.5,44.76 68.5,46.32 68.6,46.42 69.36,46.42
GND on IN3 (solid shape): 64.15,41.19 64.15,39.07 63.82,38.73 59.07,38.73 58.72,39.08 58.72,41.88 59.05,42.21 63.14,42.21
GND on IN3 (solid shape): 36.92,52.39 37.18,52.27 37.46,52.23 37.65,52.23 37.84,52.28 37.89,52.23 37.89,49.88 37.51,49.5 37.08,49.5 36.91,49.76 36.61,49.84 36.45,49.84 36.31,49.78 36.22,49.87 36.22,51.79 36.82,52.39
GND on IN3 (solid shape): 232.27,1.52 261.93,1.52 261.93,1.58 266.32,1.58 267.01,2.27 268.57,2.27 269.24,1.59 270.27,1.59 270.49,1.37 270.49,0.51 269.28,0.51 267.6,1.76 265.91,0.51 231.26,0.51 231.26,8.09 232.27,8.09
GND on IN3 (solid shape): 269.37,16.76 269.71,16.76 270.04,16.44 270.04,15.02 270.07,14.76 270.17,14.52 270.17,14.31 270.1,14.23 268.6,14.23 268.39,14.44 268.39,15.03 268.42,15.11 268.5,15.13 269.3,15.75 268.8,16.63 268.8,16.77 268.82,16.79 269.35,16.79
GND on IN3 (solid shape): 36.2,33.89 36.26,33.98 36.36,33.97 36.58,33.89 36.81,33.92 36.89,33.91 36.94,33.83 37.02,33.62 37.18,33.46 37.22,33.43 37.8,33.43 37.95,33.28 37.95,32.55 37.77,32.38 37.43,32.38 37.4,32.34 37.35,32.32 37.23,32.31 37.12,32.28 37.12,32.25 37.08,32.23 36.87,32.12 36.69,31.96 36.6,31.94 36.53,32 36.4,32.23 36.2,32.4
GND on IN3 (solid shape): 180.49,40.41 180.49,34.11 180.21,33.83 171.84,33.83 171.75,33.88 171.74,33.97 171.75,34.2 171.63,34.39 171.59,34.47 171.63,34.55 171.39,35.21 171.16,34.55 171.2,34.47 171.16,34.39 171.04,34.2 171.05,33.97 171.04,33.88 170.95,33.83 167.7,33.83 167.41,34.11 167.41,38.22 167.73,38.54 168.43,38.54 169.18,37.79 174.02,37.79 176.3,40.07 176.31,40.07 176.46,40.16 176.55,40.31 176.55,40.32 176.91,40.68 180.22,40.68
GND on IN3 (solid shape): outline of 151 points within 154.01,51.71 161.14,56.61
GND on IN3 (solid shape): 177.89,58.49 183.91,58.49 183.91,61.49 190.64,61.49 190.64,58.49 197.16,58.49 197.16,61.49 208.5,61.49 208.85,61.35 208.99,61 208.99,58.51 202.99,58.51 202.99,55.69 208.99,55.69 208.99,54.76 208.9,54.68 201.98,54.68 201.98,60.48 198.17,60.48 198.17,57.48 189.63,57.48 189.63,60.48 184.92,60.48 184.92,57.48 176.88,57.48 176.88,60.48 173.8,60.48 172.19,58.88 172.19,55.51 170.4,53.71 167.67,53.71 165.68,55.7 165.68,58.56 163.77,60.48 67.29,60.48 65.86,59.05 65.86,55.53 64.06,53.73 61.54,53.73 59.71,55.56 59.71,58.91 58.14,60.48 33.26,60.48 32.32,59.54 32.32,54.34 34.79,54.34 34.89,54.39 35.18,54.5 35.48,54.56 36.3,54.47 37.01,54.05 37.04,53.97 37,53.89 36.96,53.87 36.92,53.83 36.71,53.56 36.62,53.23 36.54,53.14 36.43,53.18 35.8,53.55 35.1,53.33 31.7,53.33 31.7,53.33 31.31,53.33 31.31,54.06 22.6,54.06 22.25,54.2 22.11,54.55 22.11,55.05 22.11,55.05 22.11,61 22.25,61.35 22.6,61.49 177.89,61.49
GND on IN3 (solid shape): outline of 86 points within 0.51,0.51 223.04,30.96
GND on IN3 (solid shape): 269.57,30.94 269.57,30.93 269.63,30.85 269.71,30.78 269.75,30.75 269.86,30.73 269.93,30.73 270.01,30.7 270.04,30.63 270.04,29.02 270.79,28.05 271.92,28.51 274.79,28.51 274.79,24.49 271.92,24.49 270.79,24.95 270.04,23.98 270.04,22.66 269.34,21.96 268.93,21.96 268.76,22.12 268.76,22.28 268.8,22.3 269.17,22.58 269.32,23.02 269.32,23.18 269.32,23.22 269.07,23.75 268.52,23.94 268.5,23.94 268.34,24.1 268.34,24.9 267.65,25.59 267.65,27.16 267.41,27.4 266.7,27.4 266.53,27.23 266.26,27.23 266.07,27.42 266.07,28.64 267.64,30.2 267.76,30.22 267.81,30.1 269.09,29.36 268.35,30.64 268.23,30.69 268.25,30.81 268.44,31 269.5,31
GND on IN3 (solid shape): outline of 252 points within 69.62,51.33 84.04,59.64
GND on IN3 (solid shape): 271.4,45.99 271.75,45.85 271.89,45.5 271.89,45.23 271.7,45.04 271.22,45.04 269.22,43.64 271.48,42.73 271.79,42.73 271.89,42.63 271.89,39.99 274.79,39.99 274.79,38.49 271.92,38.49 270.79,38.95 270.04,37.98 270.04,36.72 269.34,36.02 268.85,36.02 268.74,36.13 268.74,36.28 269.16,36.55 269.32,37.02 269.32,37.18 268.88,37.87 268.07,37.78 267.5,37.78 264.8,40.48 257.42,40.48 257.42,36.48 248.42,36.48 248.42,29.28 205.09,29.28 204.12,30.26 204,30.37 203.9,30.49 204.3,30.79 204.49,31.25 204.61,31.25 205.36,30.77 206.16,31.16 208.99,31.16 208.99,30.29 247.41,30.29 247.41,35.8 247.41,35.8 247.41,36 247.41,36.11 247.47,36.43 247.6,36.73 248.14,37.29 248.9,37.49 249.44,37.49 249.44,37.49 256.41,37.49 256.41,41 256.55,41.35 256.9,41.49 264.91,41.49 264.91,45.5 265.05,45.85 265.4,45.99
GND on GND2 (solid shape): outline of 76327 points within 0.51,0.51 274.79,61.49
GND on IN4 (solid shape): 180.49,40.41 180.49,34.11 180.21,33.83 176.93,33.83 176.66,34.1 176.66,40.42 176.91,40.68 180.22,40.68
GND on IN4 (solid shape): 102.3,34.63 102.3,31.3 102.18,31.17 100.62,31.17 100.52,31.28 100.52,34.43 100.3,34.65 100.3,34.68 100.4,34.78 102.15,34.78
GND on IN4 (solid shape): 63.56,41.79 64.15,41.19 64.15,36.96 63.71,36.52 61.35,36.52 60.92,36.95 60.92,41.88 61.26,42.21 63.14,42.21
GND on IN4 (solid shape): 36.87,52.43 37.15,52.28 37.46,52.23 37.61,52.23 37.76,52.26 37.85,52.24 37.89,52.16 37.89,50.56 37.76,50.43 37.22,50.43 36.81,50.01 36.36,50.01 36.23,50.14 36.23,51.88 36.78,52.43
GND on IN4 (solid shape): 254.3,35.92 254.36,35.9 254.4,35.85 254.37,35.64 254.46,35.45 254.54,35.37 254.54,35.35 254.46,35.28 254.46,34.79 254.95,34.79 254.98,34.83 255.22,34.83 255.26,34.78 255.26,34.02 255.14,33.9 252.73,33.9 251.41,32.58 251.31,32.55 251.24,32.64 250.69,32.82 250.88,32.28 250.96,32.21 250.94,32.1 250.56,31.72 250.45,31.7 250.39,31.8 250.39,34.99 251.32,35.92
GND on IN4 (solid shape): outline of 114 points within 99.71,27.48 103.15,28.5
