# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_PROCHOT#_CPU: length 6.3
  IN1 w0.071: v11(122.5,47.39) 122.5,47.61 122.96,48.08 122.96,48.28 122.84,48.4 122.84,48.98 122.83,48.98 122.83,50.33 v2(122.71,50.46)
  GND1 w0.117: v2(122.71,50.46) v9(122.71,50.84)
  GND2 w0.117: v9(122.71,50.84) 122.04,50.84 v8(121.97,50.76)
  BOTTOM w0.117: v4(120.39,50.38) 120.39,50.4 120.84,50.85 R168.2 121.11,50.84 121.89,50.84 v8(121.97,50.76)
H_PROCHOT#_EC: length 13.5
  BOTTOM w0.076: 56.34,8.25 55.92,8.67 55.32,8.67 55.06,8.41 U17.M1
  BOTTOM w0.117: Q31.2 66.34,8.78 65.99,9.13 R434.2 62.84,9.12 62.34,8.62 59.04,8.62 v4(58.78,8.36) 58.15,8.36 57.55,7.75 56.84,7.75 56.34,8.25
H_THRMDA: length 61.8
  TOP w0.127: Q3.2 108.12,59.48 v4(108.21,59.57) 108.62,59.57 109.19,58.99 Q3.3
  IN3 w0.127: v4(108.21,59.57) 108.53,59.25 108.53,57.92 108.15,57.54 106.83,57.54 106.32,58.05 105.94,58.05 104.59,56.7 104.59,55.92 103.57,54.9 96.91,54.9 94.35,52.34 94.35,46.7 94,46.35 94,44.29 93.53,43.82 91.82,43.82 91.37,44.28 v7(90.32,44.28)
  IN4 w0.127: v8(86.96,30.41) 86.96,32.27 84.91,34.32 84.91,39.33 89.86,44.28 v7(90.32,44.28)
  BOTTOM w0.127: U9.2 82.46,26.58 82.39,26.65 C292.1 81.48,26.65 81.1,27.03 81.1,28.13 81.8,28.83 84.24,28.83 85.71,30.3 v4(86.34,30.3) 86.85,30.3 v8(86.96,30.41)
H_THRMDA2: length 127.5
  IN3 w0.127: v4(186.96,16.14) 186.96,15.56 186.38,14.98 183.21,14.98 181.99,13.76 174.8,13.76 171.19,17.37 168.49,17.37 165.79,20.06 161.18,20.06 159.77,18.65 159.77,18 159.07,17.3 159.07,14.88 154.19,10 139.54,10 139.36,10.19 131.91,10.19 131.63,10.47 127.69,10.47 127.4,10.19 101.88,10.19 93.47,18.6 93.47,20.42 90.12,23.76 89.45,23.76 v8(88.18,25.03)
  BOTTOM w0.127: v8(88.18,25.03) 88.18,25.02 C296.1 87.81,24.63 85.69,24.63 v4(85.36,24.96) 84.91,25.42 84.91,27.27 84.6,27.58 U9.4 ; Q24.2 188.97,18.52 187.95,17.51 Q24.3 186.96,17.05 v4(186.96,16.14)
H_THRMDC: length 53.6
  TOP w0.127: v4(106.01,57.51) 106.08,57.44 Q3.1
  IN3 w0.127: v7(90.74,43.95) 91.23,43.95 91.69,43.49 93.67,43.49 94.33,44.16 94.33,46.21 94.69,46.57 94.69,52.2 97.05,54.57 103.7,54.57 106.01,56.88 v4(106.01,57.51)
  IN4 w0.127: v7(90.74,43.95) 90.04,43.95 85.24,39.15 85.24,34.5 87.29,32.44 87.29,30.26 v8(86.96,29.93)
  BOTTOM w0.127: U9.3 82.52,27.08 82.17,27.43 C292.2 81.63,28 82.13,28.5 84.72,28.5 v4(85.35,29.13) 85.92,29.7 86.74,29.7 v8(86.96,29.93)
H_THRMDC2: length 125.3
  IN3 w0.127: v8(87.42,25.05) 87.8,25.43 88.44,25.43 89.52,24.35 90,24.35 93.8,20.55 93.8,18.74 102.02,10.52 107.81,10.52 127.27,10.52 127.55,10.8 131.76,10.8 132.04,10.52 139.49,10.52 139.68,10.33 154.06,10.33 158.74,15.01 158.74,17.44 159.44,18.14 159.44,18.79 161.04,20.39 165.93,20.39 168.62,17.7 171.33,17.7 174.93,14.09 181.85,14.09 183.07,15.31 185.98,15.31 v4(186.35,15.69)
  BOTTOM w0.127: C296.2 v4(86.63,25.01) 85.47,26.18 85.47,27.35 84.73,28.08 U9.5 ; v4(186.35,15.69) 187.05,15.69 187.85,16.49 Q24.1
HDA_BITCLK_R: length 13.9
  IN1 w0.06: v11(112.74,35.39) 112.6,35.39 111.98,34.77 111.98,34.64 111.66,34.32 111.48,34.32 110.21,33.04
  IN1 w0.071: v2(102.61,28.58) 102.77,28.74 102.77,28.77 103.52,29.52 103.52,29.77 106.52,32.77 108.41,32.77 108.62,32.98 110.14,32.98 110.21,33.04
  GND1 w0.117: v2(102.61,28.58) 102.56,28.53 v9(102.56,28.23)
  GND2 w0.117: v8(102.91,28.29) 102.62,28.29 v9(102.56,28.23)
HDA_RST#_R: length 14.2
  IN1 w0.06: 110.2,32.68 111.6,34.08 111.76,34.08 112.23,34.54 112.23,34.67 112.63,35.07 112.88,35.07 112.88,35.07 v11(113.09,35.07)
  IN1 w0.071: v2(103.7,29.17) 103.7,29.31 106.27,31.88 106.27,32.13 106.64,32.5 108.58,32.5 108.76,32.68 110.2,32.68
  GND1 w0.117: v9(103.45,28.86) 103.7,29.12 v2(103.7,29.17)
  GND2 w0.117: v8(102.91,27.47) 102.91,27.79 103.42,28.3 103.42,28.84 v9(103.45,28.86)
HDA_SDOUT_R: length 19.1
  IN1 w0.06: 110.14,33.15 110.3,33.31 110.3,33.32 111.46,34.49 111.66,34.49 111.86,34.69 111.86,34.82 112.12,35.08 v11(112.12,35.29)
  IN1 w0.071: 110.14,33.15 108.57,33.15 108.31,32.9 106.45,32.9 103.39,29.84 103.39,29.59 102.6,28.8 102.52,28.8 102.09,28.38 101.84,28.38 100.24,26.78 99.08,26.78 v2(99,26.7)
  GND1 w0.117: v9(98.56,26.6) 98.89,26.6 v2(99,26.7)
  GND2 w0.117: v8(98.11,26.68) 98.2,26.6 v9(98.56,26.6)
  BOTTOM w0.117: v8(98.11,26.68) 98.02,26.77 R262.2 97.76,26.77 R244.2
HDA_SYNC_R: length 16.3
  IN1 w0.06: 110.17,32.82 111.54,34.2 111.71,34.2 112.11,34.59 112.11,34.72 112.58,35.19 112.83,35.19 112.94,35.31 112.94,35.42 v11(113.09,35.57)
  IN1 w0.071: v2(101.95,28.13) 102.58,28.13 102.72,28.26 102.72,28.37 103.03,28.68 103.03,28.82 105.84,31.63 105.84,31.9 106.57,32.64 108.53,32.64 108.72,32.82 110.17,32.82
  GND1 w0.117: v9(101.72,27.77) 101.72,27.9 v2(101.95,28.13)
  GND2 w0.117: v9(101.72,27.77) 101.89,27.77 v8(102.07,27.95)
  BOTTOM w0.117: v8(102.07,27.95) 102.07,27.74 101.83,27.5 R242.2
HG_CORE: length 1.3
  BOTTOM w0.203: 180.77,28.34 180.19,27.76 180.18,27.76 180.12,27.7 PU12.25
  vias: v4(180.97,28.61)
HG_CORE_L: length 8.3
  IN1 w0.508: v5(186.73,35.12) 186.08,35.77 183.93,35.77 183.1,34.94 183.1,33.77 v5(181.07,31.74)
  vias: v4(186.76,34.37)
HG_GT1: length 1.3
  BOTTOM w0.203: PU12.15 176.12,27.75 175.48,28.39
  vias: v4(175.43,28.68)
HG_GT1_L: length 10.1
  IN1 w0.508: v5(175.27,31.74) 174.54,32.46 174.54,36.06 171.37,39.23 v5(171.37,40.24)
  vias: v4(176.24,31.68)
HG_SA:
  vias: v4(159.71,53.86) v4(161.61,49.31) v5(158.45,53.69)
HG_SA_L:
  vias: v4(157.07,49.28) v5(156.25,49.29)
HP-L2: length 15.6
  IN3 w0.254: v4(254.45,5.22) 253.91,4.68 251.03,4.68 249.92,3.57 248.75,3.57 248.65,3.67 248.64,3.67 248.41,3.9 v4(247.72,3.9)
  BOTTOM w0.203: U19.32 247.35,4.46 247.72,4.09 v4(247.72,3.9)
  BOTTOM w0.254: R497.2 258.09,2.7 R493.1 256.47,2.7 256.46,2.71 R496.1 255.96,2.85 255.39,3.42 255.01,3.42 254.67,3.76 254.67,3.92 254.45,4.14 v4(254.45,5.22) 255.07,5.84 C447.2
HP-L3: length 7.2
  BOTTOM w0.254: CN5.3 264.41,2.61 D38.1 260.39,2.61 260.3,2.7 C471.1 259.44,2.7 259.43,2.71 R497.1 258.57,3.02 v4(258.57,3.46)
HP-R2: length 19.6
  IN3 w0.254: v4(255.96,5.53) 255.96,3.15 254.99,2.17 247.34,2.17 247.01,2.5 247.01,3.95 v4(247.11,4.05)
  BOTTOM w0.203: v4(247.11,4.05) 246.95,4.22 U19.33
  BOTTOM w0.254: C443.2 255.07,6.79 255.96,5.9 v4(255.96,5.53) R479.1 256.48,4.74 256.6,4.86 R472.1 258.09,4.86 R477.2
HP-R3: length 16.4
  IN3 w0.254: v4(259.94,4.1) 259.94,3.59 261.46,2.06 265.9,2.06 266.98,3.15 CN5.2
  BOTTOM w0.254: v4(259.94,4.1) 260.24,4.4 260.66,4.4 D34.1 260.69,4.86 C452.1 259.88,4.87 R477.1 258.57,5.18 v4(258.57,5.62)
HP_JD#: length 18.4
  BOTTOM w0.254: CN5.5 269.25,11.85 268.29,12.81 261.49,12.81 260.83,12.16 258.08,12.16 257.3,11.38 D24.1 255.94,11.38 255.86,11.46 D23.1 254.82,11.46 v4(254.42,11.05) 254.07,10.71 R418.1
I2C0_SCL: length 112.1
  TOP w0.117: U3.AB3 v3(108.81,43.34)
  IN2 w0.064: 109.37,42.68 v9(109.39,42.68)
  IN2 w0.094: v3(108.81,43.34) 108.86,43.29 108.86,42.91 109.09,42.68 109.37,42.68
  IN3 w0.094: v7(106.12,25.94) 108.86,28.68 v7(108.86,29.4) ; v7(161.18,14.05) 161.49,13.75 161.49,11.41 161.06,10.98 v8(161.06,10.65) 161.13,10.57 161.77,10.57 162,10.35 162,10.09 161.44,9.54 v8(161.44,9.35) ; v8(109.8,42.81) 109.52,42.81 v9(109.39,42.68)
  IN4 w0.071: v8(109.8,42.81) 110.38,42.81 110.71,42.48 110.71,40.7 110.46,40.44 109.54,40.44 108.86,39.76 v7(108.86,29.4) ; v7(161.18,14.05) 161.12,14.12 153.32,14.12 152.88,13.67 135.29,13.67 133.59,11.98 108.46,11.98 107.89,12.55 106.75,12.55 106.61,12.42 100.65,12.42 99.49,13.59 99.49,23.91 101.37,25.79 105.96,25.79 v7(106.12,25.94)
  BOTTOM w0.117: v8(161.06,10.65) 161,10.7 161,11.43 160.86,11.58 Q48.3 ; v8(109.8,42.81) 109.49,42.81 109.09,42.4 R10942.1
I2C0_SDA: length 109.5
  IN2 w0.064: v9(110.48,42.6) 110.7,42.82 110.74,42.82
  IN2 w0.094: v3(110.78,42.82) 110.74,42.82
  IN3 w0.094: v8(160.77,9.35) 161.66,10.25 v8(161.66,10.27) 160.96,10.27 160.67,10.55 160.67,11.11 161.18,11.62 v7(161.18,13.65) ; v8(109.8,42.45) 110.33,42.45 v9(110.48,42.6) ; v7(108.55,29.09) 108.55,28.99 107.64,28.07 107.64,27.95 v7(105.71,26.02)
  IN4 w0.071: v8(109.8,42.45) 110.03,42.45 110.43,42.04 110.43,40.93 110.23,40.72 109.43,40.72 108.58,39.87 108.58,29.12 v7(108.55,29.09) ; v7(161.18,13.65) 161.01,13.81 153.43,13.81 153,13.39 135.4,13.39 133.71,11.7 108.16,11.7 107.59,12.28 106.98,12.28 106.83,12.12 100.55,12.12 99.21,13.47 99.21,24.02 101.33,26.14 105.58,26.14 v7(105.71,26.02)
  BOTTOM w0.117: R10943.1 109.01,41.69 v4(109.34,42.02) 109.37,42.02 v8(109.8,42.45)
I2C1_SCL: length 101.3
  TOP w0.117: R10966.1 98.57,42.78 v1(97.99,42.2) 97.83,42.35 R66.1
  IN1 w0.06: 106.22,43.61 106.64,43.61 106.72,43.7 107.59,43.7 107.6,43.68 108.43,43.68 108.53,43.58 108.88,43.58 109.14,43.32 109.58,43.32 109.72,43.19 109.8,43.19 110.09,42.9 110.55,42.9 110.71,43.06 110.71,43.31 v1(110.84,43.44)
  IN1 w0.071: v3(143.3,6.73) 137.17,6.73 134.64,9.25 105.8,9.25 104.94,10.11 102.27,10.11 100.12,12.26 99.5,12.26 97.61,14.15 97.61,23.14 95.85,24.89 95.85,26.45 95.75,26.55 95.45,26.55 95.35,26.65 95.35,26.96 95.45,27.06 95.75,27.06 95.85,27.16 95.85,28 95.99,28.14 95.99,29.49 97.08,30.58 97.08,34.69 97.23,34.83 97.23,38.32 98.08,39.17 98.08,42.11 v1(97.99,42.2) 97.99,42.4 99.04,43.45 100.48,43.45 100.67,43.64 101.86,43.64 101.9,43.61 106.22,43.61
  IN2 w0.094: v3(143.3,6.73) 143.57,6.73 v9(143.81,6.48)
  IN3 w0.094: v9(143.81,6.48) 143.81,6.43 144.11,6.13 145.56,6.13 v8(145.67,6.03)
  BOTTOM w0.117: Q33.3 145.67,3.65 145.4,3.92 145.4,5.52 145.67,5.78 v8(145.67,6.03)
I2C1_SDA: length 99.6
  TOP w0.117: R60.1 97.83,43.64 97.96,43.77 v1(98.57,43.77)
  IN1 w0.06: 106.22,43.92 107.87,43.92 107.99,43.8 108.48,43.8 108.58,43.7 108.93,43.7 109.19,43.44 109.93,43.44 110.03,43.55 v1(110.28,43.55)
  IN1 w0.071: v3(144.32,6.54) 144.19,6.41 136.98,6.41 134.42,8.96 105.7,8.96 104.83,9.83 102.16,9.83 100,11.98 99.39,11.98 97.33,14.04 97.33,22.84 94.91,25.25 94.91,27.45 95.72,28.25 95.72,29.65 96.1,30.03 96.1,30.3 96.81,31 96.81,34.88 96.95,35.03 96.95,38.43 97.78,39.26 97.78,41.66 97.7,41.74 97.7,42.59 98.57,43.46 v1(98.57,43.77) 99.35,43.77 99.39,43.73 100.37,43.73 100.56,43.92 106.22,43.92
  IN2 w0.094: v9(144.72,6.46) 144.65,6.54 v3(144.32,6.54)
  IN3 w0.094: v8(146.66,6.03) 146.6,6.09 146.03,6.09 145.69,6.43 144.76,6.43 v9(144.72,6.46)
  BOTTOM w0.117: Q33.6 146.97,5.43 146.66,5.74 v8(146.66,6.03)
I2C_TP_SCL_R: length 6.3
  BOTTOM w0.117: R676.1 163.25,11.52 163.19,11.58 Q48.4 161.48,11.58 161.32,11.43 161.32,10.49 161.27,10.44 161.27,9.95 161.36,9.86 161.61,9.86 161.89,9.59 R677.2 161.89,9.1 161.45,8.66 CN16.3
I2C_TP_SDA_R: length 5.3
  BOTTOM w0.117: CN16.4 160.95,8.65 160.65,8.95 160.48,8.95 160.32,9.1 R668.2 160.32,9.71 160.47,9.86 160.9,9.86 160.95,9.91 160.95,10.17 160.84,10.28 Q48.1 159.18,10.28 159.12,10.34 R675.1
IDEA_G_3VLDO: length 9.7
  BOTTOM w0.203: PQ8.2 52.19,30.08 53.78,28.49 v4(57.4,28.49) 57.74,28.15 PR202.1 58.24,26.87 58.53,26.58 PQ9.3
IDEA_G_5VS5_PD_C1: length 7.1
  BOTTOM w0.117: PQ26.3 194.51,26.26 194.33,26.44 194.33,28.43 PR518.1 194.46,28.86 194.12,29.19 192.27,29.19 v4(192.02,29.45) 191.51,29.95 PQ27.2
IDEA_G_5VS5_PD_C2: length 6.4
  BOTTOM w0.117: PQ23.3 194.05,13.17 194.16,13.06 PR513.1 194.46,12.71 194.3,12.55 193.59,12.55 v4(193.29,12.25) 191.13,10.09 PQ24.2
ILIM_CORE: length 5.2
  BOTTOM w0.203: PU12.31 181.69,25.26 181.71,25.24 183.2,25.24 183.3,25.14 v4(183.31,25.14) PR221.1 184.04,25.13 184.59,24.58 185.12,24.58 185.36,24.82 PC157.2
ILIM_GT: length 9.1
  IN3 w0.203: v8(167.89,23.21) 168.01,23.08 170.53,23.08 170.76,22.85 v8(173.17,22.85)
  BOTTOM w0.203: PR241.1 168.01,23.08 v8(167.89,23.21) 167.79,23.3 v4(167.38,23.3) ; PU12.5 173.98,23.66 v8(173.17,22.85)
ILIM_SA: length 4.5
  BOTTOM w0.203: PU12.46 178.12,20.08 v4(178.23,19.98) 178.56,19.64 PC198.2 178.98,19.21 179.13,19.07 179.13,18.31 178.72,17.9 PR283.2
ILIMVR1: length 2.8
  GND1 w0.102: v9(67.91,44.41) 67.7,44.41 v2(67.52,44.23)
  GND2 w0.127: v9(67.91,44.41) 67.91,44.23 v8(67.54,43.86)
  BOTTOM w0.117: v8(67.54,43.86) 67.71,43.86 PR130.2 68.17,42.98 v4(68.45,42.7)
ILIMVR4: length 3.3
  TOP w0.076: v2(71.24,48.58) 71.27,48.55 71.27,47.98 PU5.D2
  GND1 w0.06: v2(71.24,48.58) 71.24,48.65 v9(71.45,48.86)
  GND2 w0.127: v9(71.45,48.86) 71.32,48.99 v8(71.32,49.34)
  BOTTOM w0.117: v8(71.32,49.34) 70.96,49.7 v4(70.96,49.82) 70.96,50.18 PR72.1
ILIMVRH3: length 4.6
  TOP w0.06: PU5.D10 v2(71.29,43.45)
  GND1 w0.06: v9(71.7,43.27) 71.52,43.45 v2(71.29,43.45)
  GND2 w0.127: v9(71.7,43.27) v8(72.06,43.27)
  BOTTOM w0.117: v4(75.18,43.42) 75.13,43.46 73.68,43.46 73.5,43.28 PR133.2 72.55,43.14 72.43,43.27 v8(72.06,43.27)
ILIMVRH5: length 2.5
  GND1 w0.06: v2(68.02,46.25) 68.02,46.14 v9(68.2,45.97)
  GND2 w0.127: v8(67.77,46.07) 68.1,46.07 v9(68.2,45.97)
  BOTTOM w0.117: v4(67.58,47) 67.91,47 68.17,46.74 PR107.1 67.91,46.45 67.77,46.3 v8(67.77,46.07)
ILIMVRL3: length 6.6
  TOP w0.06: PU5.C9 71.53,44.23 v3(71.77,43.98)
  TOP w0.117: v4(74.14,38.92) 73.91,38.92 73.47,39.36 PR49.2 73.4,39.59 73.4,40.73 v3(73.04,41.09)
  IN2 w0.094: v3(73.04,41.09) 73.1,41.14 73.1,41.49 72.77,41.82 72.77,42.15 72.05,42.86 72.05,43.5 71.77,43.78 v3(71.77,43.98)
ILIMVRL5: length 4.3
  TOP w0.064: 65.55,46.52 65.6,46.47 67.27,46.47 PU5.L5
  TOP w0.117: 64.76,46.57 65.5,46.57 65.55,46.52
  TOP w0.127: PR42.2 63.62,46.29 63.78,46.45 v4(64.04,46.45) 64.16,46.57 64.76,46.57
IMVP_PWRGD: length 123
  TOP w0.117: v4(106.75,58.44) v4(105.68,59.5) Q1.2 ; R23.2 129.8,53.62 129.66,53.76 129.66,54.68 v4(130.08,55.1) ; v4(99,52.38) 99.1,52.28 99.1,51.9 98.92,51.72 U2.1
  IN1 w0.071: v4(130.08,55.1) 130.54,54.64 130.54,54.06 130.97,53.63 136.17,53.63 144.69,45.11 151.23,45.11 156.38,39.96 156.38,34.34 157.28,33.43 157.28,27.8 157.08,27.6 157.08,27.08 159.69,24.47 160.55,24.47 166.16,18.86 168.37,18.86 170.69,16.54 172.04,16.54 172.69,15.89 174.45,15.89 174.91,15.43 181.3,15.43 181.42,15.55 v4(181.6,15.55)
  IN2 w0.094: v4(99,52.38) 99.51,52.89 100.07,52.89 100.5,52.46 101.19,52.46 101.31,52.59 101.31,53.42 102.2,54.31 102.2,56.83 103.81,58.44 v4(106.75,58.44)
  IN4 w0.071: v8(119.14,54.8) 119.12,54.8 115.89,58.02 113.27,58.02 113.09,57.84 107.23,57.84 106.75,58.33 v4(106.75,58.44)
  BOTTOM w0.117: PR294.1 182.14,16.53 182.04,16.43 PR303.2 182.04,15.89 181.71,15.55 v4(181.6,15.55) ; v4(130.08,55.1) 126.45,55.1 126.33,54.98 119.32,54.98 v8(119.14,54.8)
IMVP_PWRGD_Q: length 5.8
  TOP w0.117: R23.1 130.17,53.02 128.04,50.89 v1(127.83,50.89)
  IN1 w0.071: v1(127.83,50.89) 127.2,50.26 126.59,50.26 126.41,50.08 126.41,49.43 v11(126.45,49.39)
INT_AMIC-VREFO: length 5.6
  BOTTOM w0.203: v4(252.22,2.45) 251.98,2.21 250.24,2.21 250.1,2.35 C473.1 R486.2 250.1,4.04 249.35,4.79 U19.27
INTRUDER#: length 4.1
  IN1 w0.071: v2(112.9,36.84) 113.09,36.64 v1(113.09,36.08)
  GND1 w0.06: v2(112.9,36.84) 113.15,36.84 v9(113.24,36.93)
  GND2 w0.127: v8(113.99,36.95) 113.67,36.95 113.65,36.93 v9(113.24,36.93)
  BOTTOM w0.117: v8(113.99,36.95) 114.02,36.98 v4(114.02,38.18) 114.02,38.46 114.18,38.62 R196.2
IOUT_CORE: length 8.1
  BOTTOM w0.117: 186.08,22.26 186.56,22.74 v4(187.7,22.74)
  BOTTOM w0.203: PU12.34 182.33,24.06 184.12,22.26 ; PR247.1 186.08,22.26 185.59,22.75 184.6,22.75 184.12,22.26 ; 184.12,22.26 PC175.2
IOUT_GT: length 5.2
  BOTTOM w0.198: 174.72,21.75 175.02,22.06 PU12.1
  BOTTOM w0.203: 174.72,21.75 173.2,20.23 v4(172.56,20.23) PC188.2 PR270.1
IOUT_SA: length 5.2
  BOTTOM w0.203: PR273.2 182.51,19 182.42,18.9 v4(182.11,18.9) 181.81,18.9 181.72,18.99 PC201.2 180.64,19.74 180.27,19.74 179.32,20.69 PU12.43
ISH_ACC_INT_BASE: length 166.4
  TOP w0.06: U3.BL3 108.55,35 108.16,35 107.92,34.76 v1(107.49,34.76)
  TOP w0.117: v1(99.36,30) 97.99,30 v4(97.87,30.12) 97.87,30.32 95.93,32.27 R133.1
  IN1 w0.071: v4(193.64,42.15) 193.34,41.85 193.34,39.35 191.74,37.75 191.74,36.69 188.23,33.18 188.23,28.65 187.68,28.1 187.68,24.57 187.14,24.04 187.14,23.2 188.07,22.27 188.07,17.58 188.46,17.19 188.46,15.05 188.22,14.81 187.79,14.81 185.12,12.14 183.04,12.14 182.78,12.4 166.17,12.4 163.63,14.94 159.39,14.94 157,12.55 141.6,12.55 140.49,11.44 106.74,11.44 105.43,12.75 102.66,12.75 101.01,14.41 100.46,14.41 99.96,14.91 99.96,24.85 98.47,26.33 98.47,28.34 99.36,29.22 v1(99.36,30) 99.36,30.11 100.22,30.97 102.91,30.97 103.35,31.41 103.35,31.83 103.47,31.96 103.9,31.96 104.44,32.5 104.44,33.26 105.55,34.37 105.86,34.37 106.18,34.69 107.42,34.69 v1(107.49,34.76)
  BOTTOM w0.117: Q11.6 193.68,48.23 193.56,48.35 193.4,48.35 192.87,47.82 R180.2 192.35,47.82 192.2,47.67 192.2,45.78 194,43.97 194,42.51 v4(193.64,42.15)
ISH_ACC_INT_PANEL: length 169
  TOP w0.06: U3.BJ3 108.56,35.44 108.17,35.44 107.72,34.99 107.26,34.99 v1(107.18,34.91)
  TOP w0.117: v1(99.36,30.56) 98.19,30.56 v4(96.13,32.63) 95.77,32.98 R130.1
  IN1 w0.071: v2(193.8,48.61) 194.2,48.2 194.2,45.61 194.03,45.43 194.03,41.84 193.49,41.31 193.49,36.9 188.46,31.87 188.46,28.69 187.82,28.04 187.82,24.12 188.2,23.74 188.2,17.64 188.6,17.24 188.6,14.99 188.28,14.67 187.85,14.67 185.18,12 182.99,12 182.73,12.26 166.02,12.26 163.48,14.8 159.44,14.8 157.06,12.42 143.12,12.42 142.01,11.31 106.69,11.31 105.38,12.61 102.61,12.61 100.95,14.27 100.4,14.27 99.74,14.93 99.74,24.87 98.34,26.27 98.34,28.39 99.13,29.19 99.13,30.33 v1(99.36,30.56) 99.54,30.56 100.08,31.11 102.82,31.11 103.19,31.48 103.19,31.96 103.4,32.16 103.91,32.16 104.24,32.49 104.24,33.43 104.74,33.94 104.74,34.28 105.01,34.54 105.84,34.54 106.12,34.83 107.09,34.83 v1(107.18,34.91)
  GND1 w0.127: v9(195.07,48.88) 194.07,48.88 v2(193.8,48.61)
  GND2 w0.127: v8(195.98,48.88) v9(195.07,48.88)
  BOTTOM w0.117: R178.2 195.55,48.88 195.4,48.73 195.09,48.73 194.98,48.84 Q11.3
ISH_DISABLE_KB#: length 87
  TOP w0.06: U3.BJ4 108.93,35.81 108.45,35.81 108.29,35.97 108.02,35.97
  TOP w0.102: 106.88,35.57 107.28,35.97 108.02,35.97
  TOP w0.117: 106.88,35.57 106.52,35.22 v1(106.52,35.19) ; R124.1 96.04,33.64 96.34,33.64 97.05,32.93 v4(97.48,32.93) 97.48,32.85 v1(99.21,31.12)
  IN1 w0.071: v1(106.52,35.19) 106.1,35.19 105.84,34.93 104.14,34.93 103.73,34.52 103.28,34.52 103.17,34.4 102.87,34.4 102.79,34.48 102.25,35.02 100.72,35.02 100.17,34.47 100.17,33.59 99.92,33.33 99.43,33.33 99.16,33.05 99.16,31.35 99.21,31.3 v1(99.21,31.12) 99.21,30.74 98.98,30.51 98.98,29.23 98.2,28.45 98.2,25.63 99.6,24.22 99.6,14.88 100.35,14.13 100.9,14.13 102.55,12.48 105.32,12.48 106.63,11.17 143.34,11.17 v4(144.09,11.92)
  BOTTOM w0.117: R459.2 145.94,9.48 145.64,9.79 145.64,10.53 145.31,10.85 144.27,10.85 144.01,11.11 144.01,11.84 v4(144.09,11.92)
ISH_DISABLE_TP#: length 90.9
  TOP w0.117: R128.1 95.78,33.26 96.23,33.26 v4(97.89,31.6) 98.27,31.22 v1(98.7,31.22)
  IN1 w0.071: v3(148.1,9.38) 147.06,9.38 146.95,9.27 141.48,9.27 139.86,10.89 106.52,10.89 105.21,12.2 102.44,12.2 100.78,13.86 100.23,13.86 99.33,14.76 99.33,23.74 97.77,25.3 97.77,28.87 98.7,29.81 98.7,31.22 v1(98.7,31.22) 98.7,33.05 99.59,33.94 99.84,33.94 99.9,34 99.9,34.58 100.11,34.79 100.11,35.47 100.82,36.17 100.82,36.26 101.09,36.53 101.47,36.53 101.81,36.86 103.65,36.86 103.79,36.73 104.15,36.73 104.37,36.95 105.29,36.95 105.64,36.6 106.21,36.6 106.58,36.97 107.49,36.97 107.82,36.64 108.64,36.64 108.68,36.67 v11(109.05,36.67)
  IN2 w0.094: v9(147.62,9.28) 147.77,9.28 147.87,9.38 v3(148.1,9.38)
  IN3 w0.094: v8(147.97,9.28) v9(147.62,9.28)
  GND2 w0.127: v9(147.62,9.28) v8(147.97,9.28)
  BOTTOM w0.117: v8(147.97,9.28) 147.87,9.28 147.36,8.77 146.6,8.77 R466.2
ISH_GP0: length 7.6
  TOP w0.117: T28.1 104.91,38.14 v1(105.08,37.97)
  IN1 w0.06: 110.76,36.35 110.76,36.4 110.33,36.83 110.2,36.83 109.77,37.25 109.77,37.39 109.64,37.52 109.37,37.52 109.31,37.46 108.96,37.46 108.56,37.05 107.98,37.05 107.45,37.59
  IN1 w0.071: v1(105.08,37.97) 105.33,37.97 105.72,37.59 107.45,37.59 ; 110.76,36.35 v11(110.76,36.3)
ISH_GP2: length 4.8
  TOP w0.06: v1(106.88,35.06) 106.96,35.14 107.57,35.14 108.1,35.67 U3.BJ1
  TOP w0.117: T34.1 104.54,34.78 v1(104.61,34.7)
  IN1 w0.071: v1(106.88,35.06) 106.78,34.96 106.06,34.96 105.92,34.82 105.91,34.82 105.89,34.8 104.71,34.8 v1(104.61,34.7)
ISH_I2C0_SCL: length 204.9
  IN1 w0.06: v11(109.3,46.04) 109.21,46.13 108.91,46.13 108.83,46.21 106.77,46.21 106.36,45.8
  IN1 w0.071: v4(191.87,49.34) 191.95,49.26 194.13,49.26 195.33,48.06 195.33,42.85 196.26,41.91 196.26,33.75 195.2,32.68 193.97,32.68 193.34,33.31 191.49,33.31 189.94,31.75 189.94,28.63 188.9,27.59 188.9,25.08 190.44,23.54 190.44,17.07 190.01,16.63 190.01,14.87 188.73,13.59 188.3,13.59 185.63,10.92 180.94,10.92 180.05,10.03 174.31,10.03 174.24,9.95 169.86,9.95 v3(169.82,9.91) ; v3(155.11,7.27) 151.28,7.27 150.71,6.69 150.71,6.68 149.83,5.8 134.31,5.8 133.39,6.72 122.39,6.72 122.13,6.98 106.09,6.98 104.24,8.84 100.41,8.84 98.6,10.64 98.6,10.98 96.06,13.51 96.06,17.98 95.42,18.63 95.42,22.89 93.48,24.83 93.48,27.79 94.42,28.73 94.42,30.51 95.29,31.37 95.29,35.24 95.1,35.44 95.1,36.92 95.55,37.37 95.55,39.77 95.48,39.84 95.26,39.84 95.19,39.91 95.19,40.05 95.26,40.12 95.48,40.12 95.55,40.19 95.55,41.22 96.44,42.11 96.44,43.07 v1(96.74,43.37) 96.39,43.73 96.39,44.07 96.77,44.45 96.77,44.53 96.84,44.61 97.2,44.61 97.3,44.71 97.3,44.84 97.2,44.94 96.84,44.94 96.76,45.02 96.76,45.44 97.13,45.81 100.3,45.81 100.93,46.44 102.74,46.44 103.07,46.77 104.9,46.77 105.86,45.8 106.36,45.8
  IN2 w0.094: v3(169.82,9.91) 165.18,9.91 162.75,7.48 161.67,7.48 159.35,5.16 156.54,5.16 155.11,6.59 v3(155.11,7.27)
  BOTTOM w0.117: Q10.3 191.02,52.09 191.1,52.18 191.33,52.18 191.41,52.1 191.41,48.93 191.54,48.81 R179.2 v4(191.87,49.34)
ISH_I2C0_SDA: length 206.1
  IN1 w0.06: v1(109.79,46.04) 109.59,46.04 109.38,45.83 109.21,45.83 109.06,45.98 108.73,45.98 108.62,46.09 106.91,46.09 106.79,45.97 ; 103.63,46.49 104.98,46.49 105.22,46.26
  IN1 w0.071: v3(169.67,10.23) 174.13,10.23 174.2,10.3 179.93,10.3 180.83,11.19 185.51,11.19 188.18,13.87 188.62,13.87 189.73,14.98 189.73,23.86 188.62,24.97 188.62,27.71 189.37,28.46 189.37,31.58 191.46,33.66 193.39,33.66 194.09,32.96 194.92,32.96 195.99,34.03 195.99,41.79 195.05,42.73 195.05,47.95 194.01,48.99 190.29,48.99 189.92,49.36 189.58,49.36 188.53,50.41 188.53,50.69 188.18,51.04 v4(187.9,51.04) ; v3(154.78,7.58) 151.2,7.58 149.7,6.08 134.5,6.08 133.58,6.99 122.51,6.99 122.24,7.26 106.21,7.26 104.35,9.11 100.53,9.11 99.09,10.55 99.09,10.89 96.34,13.65 96.34,22.36 93.76,24.94 93.76,27.66 94.7,28.6 94.7,30.39 95.56,31.26 95.56,35.28 95.97,35.69 95.97,40.28 96.29,40.6 96.29,41.57 96.74,42.03 v1(96.74,42.66) 96.74,42.98 97.59,43.84 97.59,45.18 97.95,45.53 100.42,45.53 101.05,46.16 102.86,46.16 103.19,46.49 103.63,46.49 ; 106.79,45.97 106.49,45.67 105.81,45.67 105.22,46.26
  IN2 w0.094: v3(154.78,7.58) 155.23,7.58 155.41,7.39 155.41,6.71 156.66,5.46 159.23,5.46 161.55,7.78 162.63,7.78 165.08,10.23 v3(169.67,10.23)
  BOTTOM w0.117: v4(187.9,51.04) 187.09,50.22 v4(187.09,49.05) 187.09,48.68 188.15,47.62 R184.2 188.77,46.9 189.02,46.65 189.58,46.65 189.72,46.79 Q10.6
ITP_MODE: length 5.7
  TOP w0.117: R22.1 129.3,52.61 127.87,51.17 126.97,51.17 126.49,50.69 126.49,50.38 126,49.9 U3.A60
JTAG_TCK: length 6.7
  TOP w0.117: T4.1 125.88,55 125.88,53.63 124.4,52.15 124.4,50.15 124.04,49.79 U3.B53
JTAGX_R: length 6.2
  TOP w0.117: R19.1 123.65,54.29 v4(123.31,53.96) 123.67,53.6 123.67,53 123.01,52.34 123.01,50.12 122.75,49.87 U3.B49
JTCKC: length 18.1
  IN3 w0.094: v8(160.78,7.47) 161.23,7.93 163.62,7.93 165.15,9.46 165.15,11.78 165.3,11.93 165.3,12.95 164.79,13.47 164.79,14.2 164.95,14.36 165.4,14.36 v8(165.47,14.28)
  BOTTOM w0.117: U20.A6 154.17,6.79 154.65,7.27 158.63,7.27 158.75,7.15 160.14,7.15 160.47,7.47 v8(160.78,7.47)
JTMSC: length 19.2
  IN3 w0.094: v8(160.12,7.47) 160.27,7.47 160.88,8.09 163.55,8.09 164.15,8.69 164.15,8.72 164.99,9.56 164.99,11.85 165.14,12 165.14,12.89 164.96,13.07 164.63,13.4 164.63,14.27 164.98,14.61 v8(165.25,14.61)
  BOTTOM w0.117: v8(160.12,7.47) 160.04,7.4 158.76,7.4 158.71,7.45 156.23,7.45 v4(155.95,7.73) 155.67,7.45 154.58,7.45 154.17,7.04 153.81,7.04 U20.B6 ; v8(165.25,14.61) 165.25,14.87 165.37,14.99 R420.1
L_SPK+: length 249.8
  TOP w0.762: 89.59,6.81 89.59,10.76 88.82,11.54 81.18,11.54 79.73,12.99 69.03,12.99 61.6,5.56 56.65,5.56 54.25,7.96 50.01,7.96 47.47,5.41 11.26,5.41 10.38,4.53
  IN2 w0.762: 233.34,9.56 232.53,10.37 217.48,10.37 213.61,6.5 213.61,3.79 212.69,2.88 139.29,2.88 138.02,4.15 132.3,4.15 130.92,5.53 103.36,5.53 102.77,4.93 92.44,4.93 91.47,5.9 90.32,5.9
  BOTTOM w0.508: v4(233.4,8.82) 233.58,8.63 v4(234.13,8.63) C432.2 237.74,8.63 v4(237.89,8.79) 238.36,9.26 240.52,9.26 241.79,7.99 243,7.99
  vias: v4(9.37,3.72) v4(9.72,3.18) v4(10.08,3.72) v4(88.94,5.52) v4(89.27,6.08) v4(89.58,5.52)
L_SPK-: length 248.5
  TOP w0.762: 90.57,6.03 90.57,11.15 89.22,12.5 81.58,12.5 80.13,13.95 68.63,13.95 61.2,6.53 57.05,6.53 54.65,8.92 49.61,8.92 47.07,6.38 10.69,6.38
  IN2 w0.762: 92.12,3.97 103.17,3.97 103.76,4.57 130.52,4.57 131.9,3.18 137.3,3.18 137.76,2.72 138.57,1.91 213.13,1.91 214.75,3.54 214.75,6.28 217.88,9.41 231.41,9.41
  BOTTOM w0.508: v4(232.53,8.54) v4(232.53,9.2) 232.53,9.43 232.99,9.89 C420.2 234,9.44 237.54,9.44 238.07,9.97 v4(240.1,9.97) 240.7,9.97 242,8.67 242.39,8.67
  vias: v4(9.26,6.56) v4(9.6,7.12) v4(9.93,6.56) v4(90.88,4.3) v4(91.18,4.86) v4(91.51,4.3)
LAD0: length 227.9
  TOP w0.117: v4(195.12,37.02) 195.18,37.07 v4(196.13,37.07) 196.52,36.68 197.88,36.68 198.42,37.23 R106.2
  IN2 w0.064: 110.76,35.08 v3(110.76,35.32) 110.23,35.32 109.57,34.66 108.98,34.66 108.9,34.58 106.7,34.58 106.48,34.37 105.86,34.37
  IN2 w0.066: 105.86,34.37 105.52,34.37 103.87,36.02 103.85,36.02
  IN2 w0.094: v4(56.99,9.11) 57.12,9.24 57.12,9.77 56.66,10.23 56.66,14.38 59.27,16.99 60.51,16.99 62.17,18.65 62.17,20.65 62.83,21.31 62.83,23.71 64.99,25.86 75.3,25.86 76.35,24.82 83,24.82 83.81,24.01 86.25,24.01 91.32,29.08 92.88,29.08 98.58,34.78 98.58,35.43 99.35,36.2 100.94,36.2 101.08,36.06 103.81,36.06 103.85,36.02 ; 110.76,35.08 110.76,35.03 109.52,33.79 109.42,33.79 106.93,31.3 104.52,31.3 101.99,28.76 101.56,28.76 99.82,27.02 99.82,25.74 97.5,23.42 97.5,16.07 103.75,9.81 125.42,9.81 126.72,11.11 151.29,11.11 152.48,12.3 156.98,12.3 158.03,13.35 158.03,14.66 159.75,16.38 159.75,17.9 161.01,19.16 167.88,19.16 169,20.28 171.8,20.28 172.47,19.61 173.67,19.61 174.27,19 182,19 185.9,22.91 187.57,22.91 188.91,24.25 189.59,24.25 191.03,25.69 191.03,32.98 192.43,34.37 195.32,34.37 195.83,34.88 195.83,36.41 195.22,37.02 v4(195.12,37.02)
  BOTTOM w0.076: 56.64,9.22 55.34,9.22 55.15,9.41 U17.K1
  BOTTOM w0.117: 56.64,9.22 56.88,9.22 v4(56.99,9.11)
LAD1: length 227.5
  TOP w0.117: R111.2 198.35,36.46 v4(198.2,36.31) 197.81,35.92 196.59,35.92 196.11,36.41 v4(195.12,36.41)
  IN2 w0.064: 105.86,34.65 105.92,34.71 108.85,34.71 108.93,34.79 109.52,34.79 109.9,35.17 109.9,35.49 v3(110.01,35.6) 110.8,35.6 111.01,35.38 111.01,35.28
  IN2 w0.066: 101.24,36.81 101.45,36.81 101.97,36.3 103.98,36.3 105.63,34.65 105.86,34.65
  IN2 w0.094: 111.01,35.28 111.01,34.97 109.61,33.57 109.52,33.57 107.02,31.07 104.61,31.07 102.08,28.54 101.65,28.54 100.04,26.93 100.04,25.65 97.72,23.33 97.72,16.17 103.86,10.03 125.33,10.03 126.62,11.33 151.11,11.33 152.3,12.52 156.89,12.52 157.75,13.39 157.75,14.76 159.53,16.54 159.53,17.99 160.92,19.38 167.79,19.38 168.91,20.5 171.91,20.5 172.58,19.83 173.76,19.83 174.36,19.23 181.9,19.23 185.81,23.13 186.52,23.13 187.87,24.48 189.38,24.48 190.42,25.51 190.42,32.68 192.37,34.63 195.22,34.63 195.57,34.98 195.57,36 195.17,36.41 v4(195.12,36.41) ; v4(56.71,9.64) 56.62,9.64 56.23,10.03 56.23,14.34 59.28,17.38 59.68,17.38 60.19,17.88 60.19,18.14 61.21,19.16 61.21,21.83 60.83,22.21 60.83,23.22 63.69,26.09 75.59,26.09 76.55,25.13 84.07,25.13 84.27,24.92 86.85,24.92 91.23,29.3 92.79,29.3 98.36,34.87 98.36,35.52 99.26,36.42 100.09,36.42 100.48,36.81 101.24,36.81
  BOTTOM w0.076: U17.J2 54.39,9.93 54.61,10.15 56.2,10.15 56.64,9.72
  BOTTOM w0.117: 56.64,9.72 v4(56.71,9.64)
LAD2: length 225.2
  TOP w0.117: v4(195.12,35.8) 195.73,35.8 196.08,35.44 v4(196.59,35.44) 196.82,35.67 198.47,35.67 198.5,35.7 R116.2
  IN2 w0.064: 111.23,35.5 111.23,35.59 111.15,35.68 110.79,36.03 v3(110.43,36.03) 110.08,36.03 109.77,35.73 109.77,35.22 109.47,34.91 108.88,34.91 108.81,34.85 105.94,34.85
  IN2 w0.066: 105.94,34.85 104.2,36.59 102.02,36.59 101.57,37.03 100.99,37.03
  IN2 w0.094: v4(195.12,35.8) 195.11,35.8 195.09,35.8 194.37,35.08 192.37,35.08 190.12,32.83 190.12,25.52 189.29,24.7 187.78,24.7 186.43,23.35 185.72,23.35 181.81,19.45 174.46,19.45 173.85,20.05 172.71,20.05 172.04,20.72 168.81,20.72 167.69,19.6 160.83,19.6 159.29,18.06 159.29,16.66 157.47,14.84 157.47,13.42 156.8,12.75 152.2,12.75 151.01,11.55 126.53,11.55 125.23,10.25 103.97,10.25 97.94,16.28 97.94,23.23 100.26,25.55 100.26,26.79 100.91,27.44 100.91,27.48 101.75,28.32 102.17,28.32 104.7,30.85 107.11,30.85 109.02,32.76 109.11,32.76 111.23,34.88 111.23,35.5 ; 100.99,37.03 100.39,37.03 100,36.64 99.17,36.64 98.14,35.61 98.14,34.96 92.7,29.53 91.13,29.53 86.76,25.15 84.47,25.15 84.27,25.36 76.75,25.36 75.8,26.31 63.28,26.31 60.57,23.6 60.57,21.95 60.95,21.57 60.95,19.39 59.96,18.4 59.96,17.98 59.77,17.79 59.59,17.61 59.07,17.61 55.93,14.46 55.93,9.95 56.13,9.74 v4(56.13,9.62)
  BOTTOM w0.076: U17.J1 54.97,10 55.75,10 v4(56.13,9.62)
LAD3: length 225.4
  TOP w0.117: v4(194.66,33.95) 195.68,33.95 v4(195.86,34.13) 197,34.13 197.56,34.68 198.29,34.68 198.55,34.94 R120.2
  IN2 w0.064: 108.82,33.81 108.91,33.9 108.91,34.02 v3(109.2,34.31) 109.07,34.31
  IN2 w0.074: 105.99,33.81 106.44,33.81 106.94,34.31 109.07,34.31
  IN2 w0.094: 108.82,33.81 106.75,31.74 104.09,31.74 102.83,30.48 100.42,30.48 100.04,30.11 100.04,27.87 99.35,27.18 99.35,25.9 97.06,23.6 97.06,15.85 103.54,9.37 126.15,9.37 127.44,10.67 151.6,10.67 152.79,11.86 157.18,11.86 158.49,13.18 158.49,14.38 160.2,16.09 160.2,17.66 161.24,18.71 169.86,18.71 170.31,19.17 173.48,19.17 174.08,18.56 176.96,18.56 177.62,17.9 178.56,17.9 179.16,18.5 184.78,18.5 185.92,19.64 186.71,19.64 187.32,20.25 187.32,22.03 189.1,23.81 189.86,23.81 192.2,26.14 192.2,26.68 194.91,29.4 194.91,33.7 v4(194.66,33.95) ; v4(57.55,9.79) 57.55,10.48 57.11,10.92 57.11,13.89 58.12,14.9 63.5,14.9 63.92,14.49 72.1,14.49 73.38,15.76 81.7,15.76 81.87,15.58 85.43,15.58 87.28,17.43 89.51,17.43 90.67,18.58 90.67,23.61 90.01,24.26 90.01,27.12 91.53,28.64 93.07,28.64 98.69,34.27 98.87,34.27 100.22,35.62 100.92,35.62 101.05,35.49 103.71,35.49 105.39,33.81 105.99,33.81
  BOTTOM w0.076: 56.64,10.7 55.72,10.7 55.68,10.65 54.79,10.65 54.55,10.41 U17.H2
  BOTTOM w0.117: v4(57.55,9.79) 57.55,10.48 57.33,10.7 56.64,10.7
LAN_WAKE#: length 6.5
  IN2 w0.064: v9(107.26,35.49) 107.26,35.49 108.03,35.49 108.98,36.43 109.95,36.43 110.07,36.55 v3(111.8,36.55)
  GND2 w0.127: v9(107.26,35.49) 107.34,35.57 107.34,36.3 v8(106.88,36.76)
LDO3V: length 133.3
  TOP w0.305: v4(49.78,25) 49.24,25 49.09,24.85 43.38,24.85 40.92,22.39 40.92,17.26 43.5,14.68 43.5,14.47 44.41,13.56 47.96,13.56 49.12,12.4 57.02,12.4 58.79,10.62 58.79,9.58 59.89,8.49 60.49,8.49 v4(60.88,8.1) ; v4(88.87,54.24) 88.87,53.98 89.26,53.58 PU8.5
  IN1 w0.305: v4(65.3,34.4) 65.3,41.31 65.35,41.37 ; v4(49.78,25) 50.36,25 50.79,25.43 56.15,25.43 v4(56.31,25.59) 56.37,25.52 58.63,25.52 59.38,26.27 64.1,26.27 v4(64.66,26.84) v4(69.41,26.84)
  GND1 w0.203: v2(65.09,48.73) 64.84,48.48 v9(64.84,48.3) ; v9(66.14,49.01) v2(66.7,49.01)
  GND1 w0.254: v9(65.99,44.49) 66.28,44.49 v2(66.52,44.73)
  IN3 w0.305: v4(56.31,25.59) 55.87,26.02 v8(53.21,26.02) ; v7(73.96,50.64) 76.96,50.64 81.55,55.23 85.15,55.23 85.5,54.82 88.36,54.82 88.87,54.31 v4(88.87,54.24)
  GND2 w0.203: v8(65.73,49.21) 65.94,49.21 v9(66.14,49.01) ; v9(64.84,48.3) 65.2,47.94 v8(65.25,47.94) ; v9(65.99,44.49) 65.99,44.75 66.44,45.2 v7(66.6,45.2)
  IN4 w0.305: v8(76.01,26.82) 71.41,26.82 70.79,27.44 70.01,27.44 v4(69.41,26.84) ; v8(53.21,24.23) v8(53.21,26.02) ; v8(67.31,44.97) 67.08,45.2 v7(66.6,45.2) ; v7(73.96,50.64) 73.57,50.25 72.82,50.25 71.8,51.26 71.1,51.26 70.35,50.52 v4(70.35,50.32)
  BOTTOM w0.178: 69.14,44.85 69.26,44.97 69.26,45.56 69.36,45.66 PR115.2 70.03,45.66 70.2,45.48 70.2,44.76 70.48,44.49 PR126.1 70.73,44.49 71.07,44.82 71.45,44.82 PR120.1
  BOTTOM w0.203: PR96.1 65.02,48.17 v8(65.25,47.94) PR101.1 ; PR84.1 65.35,49.12 65.44,49.21 v8(65.73,49.21) ; PR216.2 64.52,26.75 64.6,26.83 v4(64.66,26.84)
  BOTTOM w0.254: v8(67.31,44.97) 67.31,44.64 v4(67.58,44.37) 68.05,43.91 68.81,43.91 69.14,44.24 69.14,44.85
  BOTTOM w0.305: v4(60.88,8.1) 61.62,8.1 62.81,6.92 v4(62.81,6.33) PR491.2 ; v4(56.31,25.59) PR211.2 56.67,26.23 56.9,26.01 PR214.2 ; v4(65.3,34.4) 65.3,30.72 64.81,30.23 64.81,29.45 64.41,29.04 64.41,27.67 64.66,27.41 v4(64.66,26.84) ; PU10.5 v8(76.01,26.82)
  vias: v1(66.36,41.54) v1(66.36,41.16) v1(66.36,40.83) v1(66.8,41.54) v1(66.8,41.16) v1(66.8,40.81) v1(67.33,51.65) v1(68.78,50.41) v1(69.13,50.41) v1(69.21,50.08) v1(69.49,50.41) v1(69.64,50.08) v4(62.14,44.52) v4(62.78,44.52)
LDO5V: length 250
  TOP w0.117: PU3.4 v4(89.25,49.42)
  TOP w0.152: PU6.4 v4(88.82,47.03)
  TOP w0.178: v4(82.83,54.39) 82.83,54.8 82.67,54.96 PU1.4
  TOP w0.254: PU5.B4 v2(72.29,47)
  TOP w0.305: v1(67.02,35.62) 67.02,32.85 68.14,31.73 72.63,31.73 73.73,30.64 81.89,30.64 82.94,29.6 v4(84.7,29.6) 86.99,29.6 87.45,30.06 90.15,30.06 90.45,29.76 92.17,29.76 94.79,27.14 95.75,27.14 96.96,25.93 96.96,24.46 100.1,21.33 100.1,14.49 102.53,12.05 105.55,12.05 106.59,11.02 125.79,11.02 126.19,11.41 154.17,11.41 156.84,14.08 162.6,14.08 164.92,11.77 179.95,11.77 v4(179.95,11.76) 179.96,11.77 185.22,11.77 187.89,14.43 188.36,14.43 189.58,15.65 v4(189.58,17.13) 189.58,18.76 192.01,21.19 192.2,21.19 193.5,22.49 v4(193.9,22.49)
  IN1 w0.305: v1(70.96,41.13) 70.96,40.49 70.29,39.82 67.37,39.82 67.02,39.48 v1(67.02,35.62)
  GND1 w0.203: v2(66.97,43.73) 66.97,43.63 66.49,43.14 v9(66.49,43.09)
  GND1 w0.254: v9(72.87,47.13) 72.42,47.13 v2(72.29,47)
  IN2 w0.305: v9(75.3,47.16) 75.11,47.35 73.09,47.35 v9(72.87,47.13)
  IN3 w0.305: v4(88.82,47.03) 89.25,47.46 v4(89.25,49.42) 88.8,49.87 88.8,49.91 86.38,52.33 86.38,52.67 85.63,53.42 83.8,53.42 v4(82.83,54.39) 82.4,53.96 81.27,53.96 75.62,48.31 75.65,48.28 75.65,47.5 v9(75.3,47.16) 74.96,46.82 74.54,46.82 73.84,46.12 73.84,45.03 75.05,43.82 75.05,40.65 v4(73.91,39.51) 73.19,38.79 70.51,38.79 70.14,39.16 67.26,39.16 66.68,38.59 65.28,38.59 64.61,39.26 64.61,42.99 ; v9(66.49,43.09) 64.71,43.09 64.61,42.99 ; 64.61,42.99 v4(64.61,45.56)
  GND2 w0.203: v9(75.3,47.16) 75.55,47.16 v8(75.93,47.54) ; v9(72.87,47.13) 72.59,47.41 v8(72.59,47.84) ; v9(66.49,43.09) 66.49,42.99 66.34,42.84 v8(66.26,42.84)
  IN4 w0.305: v4(179.95,11.76) 179.95,11.54 180.33,11.17 v8(180.33,10.14) 180.33,9.77 181.22,8.87 182.82,8.87 184,10.05 184.66,10.05 v8(184.78,10.17)
  BOTTOM w0.152: PC97.2 89.07,46.14 88.82,46.4 v4(88.82,47.03) ; v4(89.25,49.42) 89.26,49.41 89.89,49.41 89.96,49.34 PC90.2
  BOTTOM w0.178: PU13.4 193.85,22.55 v4(193.9,22.49) 194,22.39 PC173.2 ; PC118.2 78.94,34.38 79.17,34.16 PU9.4
  BOTTOM w0.191: PU22.4 185.41,10.14 185.38,10.17 v8(184.78,10.17)
  BOTTOM w0.203: PC83.2 82.66,55.08 82.83,54.91 v4(82.83,54.39) ; PC118.2 79.12,34.64 79.42,34.94 79.42,36.18
  BOTTOM w0.305: v8(180.33,10.14) 180.33,9.75 179.57,8.99 PC178.1 178.93,8.5 178.9,8.52 PU15.10 ; v8(72.59,47.84) 72.38,48.05 72.38,48.36 72.03,48.71 PR92.2 ; v4(73.91,39.51) 74.96,38.46 77.21,38.46 79.42,36.25 79.42,36.18
  vias: v1(72.05,39.97) v1(72.36,39.77) v2(72.05,39.97) v2(72.36,39.77) v3(72.05,39.97) v3(72.36,39.77)
LFRAME#: length 218.9
  IN2 w0.064: 105.86,34.09 106.53,34.09 106.88,34.44 108.94,34.44 109.04,34.53 109.43,34.53 v3(109.65,34.31) 109.3,33.96 109.28,33.96 109.14,33.81
  IN2 w0.066: 105.86,34.09 105.71,34.09
  IN2 w0.094: 109.14,33.81 106.84,31.52 104.18,31.52 102.92,30.26 100.51,30.26 100.29,30.03 100.29,27.8 99.6,27.11 99.6,25.83 97.28,23.51 97.28,15.94 103.63,9.59 125.51,9.59 126.81,10.89 151.46,10.89 152.65,12.08 157.08,12.08 158.26,13.26 158.26,14.54 159.97,16.25 159.97,17.77 161.14,18.93 168.04,18.93 169.09,19.99 171.63,19.99 172.23,19.39 173.58,19.39 174.18,18.78 182.09,18.78 185.88,22.58 187.55,22.58 189,24.03 189.7,24.03 191.51,25.84 191.51,26.65 194.53,29.68 v4(194.53,33.31) ; v4(57.17,10.33) 56.89,10.61 56.89,14.13 59.53,16.77 60.78,16.77 62.53,18.52 62.53,20.53 63.27,21.27 63.27,23.63 65.28,25.64 75.17,25.64 76.32,24.49 82.8,24.49 83.56,23.73 86.28,23.73 91.41,28.86 92.97,28.86 98.66,34.55 98.83,34.55 100.17,35.9 100.93,35.9 100.99,35.84 103.68,35.84 105.43,34.09 105.71,34.09
  BOTTOM w0.076: U17.H1 56.64,10.41
  BOTTOM w0.117: v4(194.53,33.31) 195.11,33.31 v4(195.72,33.92) 196.29,34.49 197.21,34.49 197.55,34.83 197.94,34.83 R212.1 ; 56.64,10.41 57.08,10.41 v4(57.17,10.33)
LG_CORE: length 8.4
  IN1 w0.635: v5(181.61,35.3) 181.08,34.77 181.08,33.02 179.67,31.61 179.67,29.7 179.45,29.47 v5(179.45,28.72)
  BOTTOM w0.203: PU12.23 179.32,28.1 179.24,28.18
  vias: v4(181.02,34.91)
LG_GT1: length 13.8
  IN1 w0.635: v5(176.19,40.43) 176.19,39.68 176.04,39.52 176.04,32.07 176.43,31.69 176.43,29.35 v5(176.96,28.82)
  BOTTOM w0.117: v4(177.18,29.8) 176.73,29.8 PR185.2
  BOTTOM w0.203: PU12.17 176.92,28.2
LG_GT2: length 2.8
  BOTTOM w0.203: PR187.2 178.61,29.15 v4(178.61,28.49) 178.35,28.23 178.07,28.23 177.72,27.89 PU12.19
LG_SA:
  vias: v4(156.53,52.23)
LID1_EC#: length 61
  TOP w0.254: MR1.2 43.41,51.41 D1.1 44.18,52.42 44.19,52.43 v3(44.19,52.81) R39.1
  IN2 w0.094: v3(44.19,52.81) 43.55,52.81 41.17,50.43 41.17,49.41 39.21,47.45 39.21,35.41 41.5,33.12 41.5,28.23 47.44,22.28 48.79,22.28 49.83,21.24 50.1,21.24 v4(50.6,20.75) 50.05,20.2 45.87,20.2 45.28,19.62 45.28,17.36 v4(42.23,14.32)
  BOTTOM w0.117: D18.1 39.01,14.05 39.13,13.93 v4(40.4,13.93) 41,13.93 41.01,13.92 R389.2 41.84,13.92 v4(42.23,14.32) ; v4(50.6,20.75) R320.2 50.01,20.74 R336.1
LID1_EC#1: length 6.8
  BOTTOM w0.076: U17.A9 50.89,14.27 50.64,14.52 50.64,14.61 50.32,14.93
  BOTTOM w0.117: R336.2 50.01,19.13 49.47,18.6 49.47,17.63 C348.1 49.35,16.44 v4(49.35,16.29) 49.35,15.93 50.32,14.95 50.32,14.93
LINE1-L: length 3.7
  BOTTOM w0.203: U19.22 251.6,7.07 252.79,5.88 v4(253.52,5.88) C447.1
LINE1-R: length 3.9
  BOTTOM w0.203: U19.21 251.82,7.47 v4(252.42,6.87) 252.95,6.34 253.49,6.34 254.05,6.9 C443.1
LINE1-VREFO-L: length 10.6
  IN3 w0.254: v4(253.54,2.71) 252.27,2.71 251.82,3.15 251.4,3.15 250.92,2.68 248.12,2.68 247.77,3.04 v4(247.77,3.29)
  BOTTOM w0.203: v4(247.77,3.29) 248.18,3.7 248.18,4.1 247.75,4.53 U19.31
  BOTTOM w0.254: R496.2 v4(254.39,2.71) v4(253.54,2.71)
LINE1-VREFO-R: length 10.6
  IN3 w0.254: v4(255.18,3.97) 254.98,4.17 251.24,4.17 250.13,3.06 248.48,3.06 v4(248.38,3.17)
  BOTTOM w0.203: U19.30 248.15,4.59 248.5,4.24 248.5,3.32 248.38,3.2 v4(248.38,3.17)
  BOTTOM w0.254: R479.2 v4(255.18,3.97)
LPC_LFRAME#_C: length 7
  BOTTOM w0.117: CN1.73 203.36,33.6 202.1,34.85 201.17,34.85 200.41,35.62 199.13,35.62 198.88,35.36 198.88,35.16 198.75,35.03 R212.2 v4(198.59,34.3)
LPDDR3_RVD1: length 2.5
  TOP w0.06: v12(127.26,37.25) 127.03,37.25 126.94,37.34 U3.BB63
  GND1 w0.06: v12(127.26,37.25) 127.62,37.25 v9(127.83,37.04)
  GND2 w0.127: v8(128.19,37.37) 128.16,37.37 v9(127.83,37.04)
  BOTTOM w0.117: T44.1 v8(128.19,37.37)
LPDDR3_RVD2: length 3.7
  TOP w0.06: v11(125.42,35.16) 125.42,35.15 125.35,35.08 U3.BL57
  IN1 w0.06: v2(127.35,35.26) 126.77,35.26 126.66,35.37 125.97,35.37 125.76,35.16 v11(125.42,35.16)
  GND1 w0.06: v2(127.35,35.26) 127.55,35.26 v9(127.68,35.39)
  GND2 w0.127: v9(127.68,35.39) v8(127.68,35.01)
  BOTTOM w0.117: T53.1 127.91,34.78 v8(127.68,35.01)
LPDDR3_RVD3: length 7.3
  IN1 w0.06: 114.8,37.25 115.1,37.25 115.36,37 115.43,37 115.67,36.75 115.75,36.75 115.97,36.53 116.05,36.53 116.07,36.5 116.07,36.5 116.19,36.39 116.19,36.3 116.48,36.01 116.72,36.01 116.79,35.94 116.83,35.9 116.83,35.75 116.96,35.63 v11(116.96,35.57)
  IN1 w0.071: 114.8,37.25 113.8,37.25 113.42,37.63 v2(113.1,37.63)
  GND1 w0.06: v2(113.1,37.63) 112.89,37.43 v9(112.89,37.27)
  GND2 w0.127: v8(113.02,37.73) 113.02,37.4 v9(112.89,37.27)
  BOTTOM w0.117: v8(113.02,37.73) 112.44,37.73 112.19,37.48 T43.1
LPDDR3_RVD4: length 1.6
  GND1 w0.06: v12(117.92,35.32) 117.87,35.32 v9(117.67,35.52)
  GND2 w0.127: v9(117.67,35.52) 117.88,35.31 v8(117.88,35.08)
  BOTTOM w0.117: v8(117.88,35.08) 117.72,35.24 T51.1
M0_A_A0: length 44.2
  IN2 w0.06: v14(125.65,37.98) 125.82,37.82 128.27,37.82 128.39,37.7
  IN2 w0.109: v13(151.38,32.77) 151.28,32.77 151.02,32.52 151.02,32.09 150.95,32.01 150.18,32.01 150.11,31.94 150.11,31.78 150.18,31.71 151.38,31.71 151.45,31.63 151.45,31.48 151.38,31.4 147.01,31.4 146.93,31.33 146.93,31.17 147.01,31.1 150.77,31.1 150.85,31.01 150.85,30.87 150.77,30.78 146.37,30.78 146.3,30.7 146.3,30.54 146.37,30.46 147.29,30.46 147.36,30.39 147.36,30.25 147.29,30.17 142.11,30.17 139.19,33.09 139.19,33.49 138.64,34.04 138.24,34.04 135.9,36.39 129.96,36.39 129.15,37.19 128.9,37.19 128.39,37.7
  BOTTOM w0.102: U7A1.R2 151.09,33.06 v13(151.38,32.77)
M0_A_A1: length 43.6
  IN2 w0.06: 128.62,38.23 127.24,38.23 126.74,38.74 125.75,38.74 125.73,38.75 125.07,38.75 124.71,38.39 124.71,38.03 v14(124.67,37.98)
  IN2 w0.109: v13(150.56,33.4) 149.67,34.28 148.65,34.28 148.58,34.35 148.58,39.38 148.51,39.45 147.15,39.45 147.07,39.38 147.07,32.73 145.91,31.56 145.42,31.56 145.32,31.46 145.32,31.17 145.2,31.05 142.48,31.05 140.07,33.46 140.07,34.21 138.54,35.74 137.78,35.74 136.26,37.26 133.1,37.26 132.51,37.85 129,37.85 128.62,38.23
  BOTTOM w0.102: U7A1.P2 150.87,33.71 v13(150.56,33.4)
M0_A_A2: length 46.7
  IN2 w0.06: v14(126.39,36.37) 126.58,36.19 126.58,35.86 126.92,35.52 127.35,35.52 127.58,35.75 127.81,35.75
  IN2 w0.109: v13(153.57,34.04) 153.57,30.58 149.52,26.53 147.87,26.53 147.75,26.65 147.75,26.89 147.66,26.98 147.5,26.98 147.42,26.89 147.42,26.63 147.28,26.5 146.72,26.5 146.29,26.93 141.35,26.93 134.92,33.35 133.07,33.35 132.23,34.2 129.36,34.2 127.81,35.75
  BOTTOM w0.147: U7A1.N2 151.31,34.05 151.31,33.38 151.45,33.24 151.6,33.24 151.75,33.38 151.75,33.97 151.88,34.09 152.06,34.09 152.19,33.97 152.19,32.8 152.32,32.67 152.52,32.67 152.65,32.8 152.65,33.89 152.77,34.02 153,34.02 153.13,33.89 153.13,32.75 153.25,32.62 153.44,32.62 153.57,32.75 v13(153.57,34.04)
M0_A_A3: length 45.2
  IN2 w0.06: v14(124.91,38.31) 125.24,38.63 125.68,38.63 125.7,38.62 126.66,38.62 127.16,38.11 128.48,38.11 128.52,38.08
  IN2 w0.109: 128.52,38.08 128.98,37.62 132.4,37.62 133.06,36.97 136.14,36.97 137.66,35.45 138.41,35.45 139.77,34.09 139.77,33.34 142.36,30.75 145.51,30.75 146.74,31.99 147.19,31.99 147.37,32.17 147.37,38.39 147.44,38.46 147.67,38.46 147.75,38.39 147.75,33.54 147.89,33.4 148.44,33.4 148.58,33.54 148.58,33.87 148.66,33.94 148.86,33.94 148.94,33.87 148.94,33.48 149.02,33.41 149.19,33.41 149.27,33.48 149.27,33.88 149.36,33.97 149.51,33.97 149.6,33.88 149.6,33.47 149.68,33.4 150.07,33.4 150.46,33 150.68,33 150.92,33.24 150.92,33.53 150.53,33.92 150.53,34.04 v13(150.56,34.07)
  BOTTOM w0.102: v13(150.56,34.07) 150.26,34.36 U7A1.N3
M0_A_A4: length 45.7
  IN2 w0.064: 128.39,37.95 127.15,37.95 126.61,38.49 125.65,38.49 125.63,38.51 125.32,38.51 125.16,38.35 v14(125.16,37.98)
  IN2 w0.109: 128.39,37.95 128.98,37.37 132.33,37.37 132.4,37.29 132.4,37.09 132.33,37.02 129.97,37.02 129.89,36.94 129.89,36.75 129.97,36.68 136.02,36.68 137.55,35.15 138.3,35.15 139.48,33.97 139.48,33.22 142.24,30.46 145.63,30.46 146.86,31.69 149.13,31.69 149.35,31.91 149.35,32.32 149.25,32.41 148.31,32.41 148.29,32.39 147.77,32.39 147.67,32.49 147.67,33.01 147.76,33.1 149.95,33.1 150.15,32.91 150.15,32.36 150.21,32.3 150.64,32.3 150.73,32.39 150.73,32.64 151.46,33.37 151.46,34.86 151.37,34.95 151.26,34.95 151.17,34.86 151.17,34.37 151.1,34.3 150.93,34.3 150.85,34.39 150.82,34.39 v13(150.57,34.63)
  BOTTOM w0.102: v13(150.57,34.63) 150.57,34.66 150.22,35.01 U7A1.M3
M0_A_A5: length 42.9
  IN2 w0.06: 128.66,37.19 128.64,37.19 128.14,37.7 125.55,37.7 125.41,37.84 v14(125.41,38.31)
  IN2 w0.109: v13(150.53,39.23) 150.18,38.88 149.47,38.88 149.31,38.72 149.31,35.22 149.49,35.03 149.91,35.03 149.93,35.01 150.44,35.01 150.45,35 150.82,35 151.11,35.29 151.61,35.29 151.75,35.15 151.75,31.26 150.98,30.49 148.03,30.49 147.42,29.88 141.99,29.88 138.9,32.97 138.9,33.37 138.52,33.75 138.12,33.75 135.8,36.08 129.89,36.08 129.03,36.94 128.91,36.94 128.66,37.19
  BOTTOM w0.102: v13(150.53,39.23) 150.21,38.91 U7A1.F3
M0_A_A6: length 43.4
  IN2 w0.06: v14(124.91,37.66) 125.42,37.66 125.5,37.58 128.08,37.58 128.49,37.17 128.49,37.1
  IN2 w0.109: v13(150.53,39.88) 150.93,39.88 151.05,39.77 151.05,38.52 150.92,38.39 150.92,37.71 150.19,36.99 150.19,35.83 150.34,35.69 150.87,35.69 150.98,35.58 151.53,35.58 151.53,35.59 152.09,35.59 152.4,35.29 152.4,35.13 152.04,34.77 152.04,31.14 151.1,30.2 148.14,30.2 147.54,29.59 141.87,29.59 138.61,32.85 138.61,33.25 138.4,33.46 138,33.46 135.67,35.78 132.92,35.78 132.83,35.87 129.72,35.87 128.49,37.1
  BOTTOM w0.102: U7A1.E3 150.21,39.56 v13(150.53,39.88)
M0_A_A7: length 45.3
  IN2 w0.06: v14(125.73,36.61) 125.78,36.61 126.14,36.25 126.23,36.25 126.41,36.07 126.41,35.86 127.24,35.03 128.19,35.03
  IN2 w0.109: 128.19,35.03 129.23,33.99 132.12,33.99 133.06,33.06 134.8,33.06 141.23,26.64 146.17,26.64 146.6,26.21 149.62,26.21 153.94,30.54 153.94,37.6 152.18,39.36 v4(151.81,39.36)
  BOTTOM w0.102: v4(151.81,39.36) 151.2,39.36 U7A1.E2
M0_A_A8: length 44.8
  IN2 w0.06: 128.01,35.9 128.01,36.01 127.67,36.36 126.72,36.36 126.38,36.7 v14(126.14,36.7)
  IN2 w0.109: 128.01,35.9 129.51,34.4 132.31,34.4 133.06,33.65 135.05,33.65 141.42,27.27 147.94,27.27 148.05,27.16 148.05,26.91 148.14,26.82 148.32,26.82 148.41,26.91 148.41,27.12 148.5,27.21 148.67,27.21 148.76,27.12 148.76,26.91 148.85,26.82 149.4,26.82 153.22,30.64 153.22,34.28 153.65,34.71 153.65,37.48 152.16,38.97 151.56,38.97 151.41,39.12 v4(151.41,39.91)
  BOTTOM w0.102: U7A1.D2 151.1,40.21 v4(151.41,39.91)
M0_A_A9: length 46.1
  IN2 w0.06: v14(126.15,36.05) 126.29,35.91 126.29,35.81 127.22,34.88 128.04,34.88
  IN2 w0.109: 128.04,34.88 129.13,33.79 132.02,33.79 133.04,32.77 134.68,32.77 141.1,26.35 146.05,26.35 146.48,25.92 149.74,25.92 154.24,30.42 154.24,37.74 v13(151.45,40.53)
  BOTTOM w0.102: U7A1.C2 151.12,40.86 v13(151.45,40.53)
M0_A_CLKN0: length 44.5
  IN2 w0.06: v14(126.39,37.02) 126.56,37.02 127.1,36.48 127.8,36.48 128.18,36.09 128.18,36.06 128.19,36.05
  IN2 w0.109: v13(151.34,36.64) 151.34,36.55 151.42,36.48 152.15,36.48 152.27,36.6 152.27,36.86 151.42,37.71 151.42,38.01 151.78,38.36 152.08,38.36 153.14,37.3 153.14,34.91 152.73,34.5 152.73,30.86 149.84,27.97 148.92,27.97 148.7,27.76 141.62,27.76 135.22,34.17 133.09,34.17 132.62,34.64 129.6,34.64 128.19,36.05
  BOTTOM w0.102: v13(151.34,36.64) 151.54,36.64 151.59,36.7 151.59,37.03 151.53,37.09 151.13,37.09 U7A1.J2
M0_A_CLKN1: length 43.2
  IN1 w0.06: 131.54,36.83 131.49,36.88 131.49,36.94 130.38,38.05 127.17,38.05 126.67,37.54 126.55,37.54 126.53,37.52 126.47,37.46 126.31,37.46 126.11,37.66 v11(125.9,37.66)
  IN1 w0.089: 131.54,36.83 133.47,34.91 136.45,34.91 140.94,30.42 148.68,30.42 150.21,28.89 151.11,28.89 152.75,27.24 152.75,22.97 153.56,22.16 153.56,20.6 151.8,18.84 151.08,18.84 151.02,18.9 151.02,19.18 151.15,19.31 v13(151.34,19.31)
  BOTTOM w0.102: v13(151.34,19.31) 151.07,19.31 151,19.39 U6A1.J2
M0_A_CLKP0: length 44.5
  IN2 w0.06: v14(125.9,37.02) 126.08,37.02 126.28,37.22 126.52,37.22 127.15,36.6 127.85,36.6 128.24,36.2 128.29,36.2
  IN2 w0.109: 128.29,36.2 129.67,34.81 132.69,34.81 133.14,34.36 135.29,34.36 141.7,27.95 148.63,27.95 148.84,28.16 149.76,28.16 152.54,30.94 152.54,34.58 152.95,34.99 152.95,37.22 152,38.18 151.86,38.18 151.61,37.93 151.61,37.79 152.46,36.94 152.46,36.52 152.23,36.29 151.04,36.29 150.71,36.62 v13(150.61,36.62)
  BOTTOM w0.102: v13(150.61,36.62) 150.58,36.62 150.24,36.96 U7A1.J3
M0_A_CLKP1: length 43.2
  IN1 w0.06: v11(126.39,37.66) 126.62,37.66 127.12,38.17 130.43,38.17 131.58,37.02 131.61,37.02 131.68,36.95
  IN1 w0.089: v13(150.6,19.26) 150.84,19.02 150.84,18.83 151.01,18.66 151.87,18.66 153.74,20.53 153.74,22.24 152.93,23.04 152.93,27.32 152.03,28.22 151.18,29.06 150.28,29.06 148.75,30.59 141.01,30.59 136.52,35.08 133.54,35.08 131.68,36.95
  BOTTOM w0.102: U6A1.J3 150.57,19.26 v13(150.6,19.26)
M0_A_DQ0: length 23.3
  IN1 w0.06: v11(126.15,41.85) 126.36,41.85 126.55,41.65 126.93,41.65 127.48,42.2 127.74,42.2
  IN1 w0.089: v13(144.21,39.23) 143.79,39.66 143.79,42.82 142.84,43.76 130.47,43.76 129.84,43.13 128.67,43.13 127.74,42.2
  BOTTOM w0.147: U7A1.F10 144.28,39.23 v13(144.21,39.23)
M0_A_DQ1: length 22.2
  IN1 w0.06: v11(125.9,41.53) 126.11,41.53 126.31,41.33 126.48,41.33 126.55,41.41 126.65,41.41 126.65,41.41 127.03,41.41 127.43,41.82 128.26,41.82
  IN1 w0.089: 128.26,41.82 128.95,42.5 130.1,42.5 130.73,43.14 142.43,43.14 142.64,42.93 142.64,42.65 142.75,42.54 142.75,39.89 v13(143.41,39.23)
  BOTTOM w0.147: v13(143.41,39.23) 143.48,39.23 U7A1.F11
M0_A_DQ2: length 22.5
  IN1 w0.06: 127.48,41.31 127.13,40.97 126.95,40.97 126.86,40.88 v11(126.39,40.88)
  IN1 w0.089: 127.48,41.31 130.71,41.31 131.22,41.82 139.59,41.82 143.31,38.11 144.35,38.11 144.64,38.39 144.64,39.57 v13(145.01,39.94)
  BOTTOM w0.147: U7A1.E9 145.39,39.56 v13(145.01,39.94)
M0_A_DQ3: length 22.6
  IN1 w0.06: 127.48,41.08 127.24,40.85 127,40.85 126.91,40.76 126.55,40.76 126.48,40.68 126.31,40.68 126.11,40.88 v11(125.9,40.88)
  IN1 w0.089: v13(145.01,39.23) 145.01,38.45 144.47,37.9 143.07,37.9 139.46,41.51 131.35,41.51 130.92,41.08 127.48,41.08
  BOTTOM w0.147: v13(145.01,39.23) 145.33,38.91 U7A1.F9
M0_A_DQ4: length 21.5
  IN1 w0.06: 127.95,41.97 127.42,41.97 126.98,41.53 v11(126.39,41.53)
  IN1 w0.089: 127.95,41.97 128.8,42.82 129.97,42.82 130.6,43.45 142.6,43.45 143,43.06 143,40.19 v13(143.39,39.8)
  BOTTOM w0.147: U7A1.E11 143.56,39.8 v13(143.39,39.8)
M0_A_DQ5: length 22.8
  IN1 w0.06: 127.76,42.65 126.95,41.85 v11(126.64,41.85)
  IN1 w0.089: 127.76,42.65 128.54,43.44 129.69,43.44 130.34,44.09 142.95,44.09 144.55,42.5 144.55,40.2 v13(144.21,39.87)
  BOTTOM w0.147: U7A1.E10 144.52,39.56 144.22,39.87 v13(144.21,39.87)
M0_A_DQ6: length 23.1
  IN1 w0.06: v11(126.15,40.56) 126.36,40.56 126.55,40.36 126.72,40.36 126.88,40.52 127,40.52 127.09,40.61 127.44,40.61 127.5,40.67
  IN1 w0.089: v13(145.78,39.23) 145.78,38.38 144.9,37.5 142.59,37.5 139.2,40.89 131.78,40.89 131.57,40.67 127.5,40.67
  BOTTOM w0.147: U7A1.F8 146.1,38.91 v13(145.78,39.23)
