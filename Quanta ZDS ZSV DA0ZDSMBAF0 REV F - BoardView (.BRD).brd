# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Nets (continued)
ILIM_SA: PC198.2 PR283.2 PU12.46
ILIMVR1: PR130.2 PU5.L9
ILIMVR4: PR72.1 PU5.D2
ILIMVRH3: PR133.2 PU5.D10
ILIMVRH5: PR107.1 PU5.K5
ILIMVRL3: PR49.2 PU5.C9
ILIMVRL5: PR42.2 PU5.L5
IMVP_PWRGD: PR294.1 PR303.2 Q1.2 R23.2 U2.1
IMVP_PWRGD_Q: R23.1 U3.A62
INT_AMIC-VREFO: C473.1 R486.2 U19.27
INTRUDER#: R196.2 U3.BG19
IOUT_CORE: PC175.2 PR247.1 PU12.34
IOUT_GT: PC188.2 PR270.1 PU12.1
IOUT_SA: PC201.2 PR273.2 PU12.43
ISH_ACC_INT_BASE: Q11.6 R133.1 R180.2 U3.BL3
ISH_ACC_INT_PANEL: Q11.3 R130.1 R178.2 U3.BJ3
ISH_DISABLE_KB#: R124.1 R459.2 U3.BJ4
ISH_DISABLE_TP#: R128.1 R466.2 U3.BD4
ISH_GP0: T28.1 U3.BF11
ISH_GP2: T34.1 U3.BJ1
ISH_I2C0_SCL: Q10.3 R61.1 R179.2 U3.P5
ISH_I2C0_SDA: Q10.6 R67.1 R184.2 U3.P7
ITP_MODE: R22.1 U3.A60
JTAG_TCK: T4.1 U3.B53
JTAGX_R: R19.1 U3.B49
JTCKC: R421.1 U20.A6
JTMSC: R420.1 U20.B6
L_SPK+: C432.2 CN13.1 D37.1 U19.42
L_SPK-: C420.2 CN13.2 D33.1 U19.43
LAD0: R106.2 U3.BK11 U17.K1
LAD1: R111.2 U3.BJ8 U17.J2
LAD2: R116.2 U3.BG10 U17.J1
LAD3: R120.2 U3.BP5 U17.H2
LAN_WAKE#: R203.2 U3.BE15
LDO3V: PC26.1 PC53.1 PC54.2 PC64.2 PR11.1 PR84.1 PR85.2 PR96.1 PR101.1 PR115.2 PR120.1 PR126.1 PR204.2 PR211.2 PR214.2 PR216.2 PR491.2 PU5.D1 PU5.E1 PU5.M13 PU5.N8 PU8.5 PU10.5 Q6067.2 Q6067.5
LDO5V: PC47.2 PC63.2 PC83.2 PC90.2 PC93.1 PC97.2 PC101.2 PC118.2 PC173.2 PC178.1 PC248.2 PR92.2 PU1.4 PU3.4 PU5.B4 PU5.E13 PU5.M10 PU5.N7 PU6.4 PU9.4 PU13.4 PU15.10 PU22.4
LFRAME#: R212.1 U3.BP7 U17.H1
LG_CORE: PQ6.8 PR188.2 PU12.23
LG_GT1: PQ7.8 PR185.2 PU12.17
LG_GT2: PR187.2 PU12.19
LG_SA: PQ2.8 PU2.5
LID1_EC#: D1.1 D18.1 MR1.2 R39.1 R320.2 R336.1 R389.2
LID1_EC#1: C348.1 R336.2 U17.A9
LINE1-L: C447.1 U19.22
LINE1-R: C443.1 U19.21
LINE1-VREFO-L: R496.2 U19.31
LINE1-VREFO-R: R479.2 U19.30
LPC_LFRAME#_C: CN1.73 R212.2
LPDDR3_RVD1: T44.1 U3.BB63
LPDDR3_RVD2: T53.1 U3.BL57
LPDDR3_RVD3: T43.1 U3.BJ31
LPDDR3_RVD4: T51.1 U3.BK34
M0_A_A0: U3.AW59 U7A1.R2
M0_A_A1: U3.AW55 U7A1.P2
M0_A_A2: U3.BF62 U7A1.N2
M0_A_A3: U3.AV56 U7A1.N3
M0_A_A4: U3.AW57 U7A1.M3
M0_A_A5: U3.AV58 U7A1.F3
M0_A_A6: U3.BA56 U7A1.E3
M0_A_A7: U3.BD59 U7A1.E2
M0_A_A8: U3.BD61 U7A1.D2
M0_A_A9: U3.BG61 U7A1.C2
M0_A_CLKN0: U3.BC62 U7A1.J2
M0_A_CLKN1: U3.BA60 U6A1.J2
M0_A_CLKP0: U3.BC60 U7A1.J3
M0_A_CLKP1: U3.BA62 U6A1.J3
M0_A_DQ0: U3.AG61 U7A1.F10
M0_A_DQ1: U3.AH60 U7A1.F11
M0_A_DQ2: U3.AK62 U7A1.E9
M0_A_DQ3: U3.AK60 U7A1.F9
M0_A_DQ4: U3.AH62 U7A1.E11
M0_A_DQ5: U3.AG63 U7A1.E10
M0_A_DQ6: U3.AL61 U7A1.F8
M0_A_DQ7: U3.AL63 U7A1.D9
M0_A_DQ8: U3.AM60 U7A1.M8
M0_A_DQ9: U3.AM62 U7A1.P9
M0_A_DQ10: U3.AT60 U7A1.N10
M0_A_DQ11: U3.AR61 U7A1.M10
M0_A_DQ12: U3.AN61 U7A1.M9
M0_A_DQ13: U3.AN63 U7A1.N9
M0_A_DQ14: U3.AR63 U7A1.M11
M0_A_DQ15: U3.AT62 U7A1.N11
M0_A_DQ16: U3.AT56 U7A1.T10
M0_A_DQ17: U3.AR55 U7A1.R11
M0_A_DQ18: U3.AN57 U7A1.R9
M0_A_DQ19: U3.AN55 U7A1.T9
M0_A_DQ20: U3.AR57 U7A1.T11
M0_A_DQ21: U3.AT58 U7A1.R10
M0_A_DQ22: U3.AM58 U7A1.R8
M0_A_DQ23: U3.AM56 U7A1.T8
M0_A_DQ24: U3.AL55 U7A1.C10
M0_A_DQ25: U3.AL57 U7A1.C11
M0_A_DQ26: U3.AH58 U7A1.B9
M0_A_DQ27: U3.AH56 U7A1.B8
M0_A_DQ28: U3.AK58 U7A1.B11
M0_A_DQ29: U3.AK56 U7A1.B10
M0_A_DQ30: U3.AG55 U7A1.C8
M0_A_DQ31: U3.AG57 U7A1.C9
M0_A_DQ32: U3.BE55 U6A1.F10
M0_A_DQ33: U3.BC55 U6A1.E10
M0_A_DQ34: U3.BG53 U6A1.E9
M0_A_DQ35: U3.BE53 U6A1.F9
M0_A_DQ36: U3.BC53 U6A1.E11
M0_A_DQ37: U3.BG55 U6A1.F11
M0_A_DQ38: U3.BD52 U6A1.F8
M0_A_DQ39: U3.BF52 U6A1.D9
M0_A_DQ40: U3.BC51 U6A1.M8
M0_A_DQ41: U3.BE51 U6A1.N9
M0_A_DQ42: U3.BC49 U6A1.N11
M0_A_DQ43: U3.BE49 U6A1.M11
M0_A_DQ44: U3.BG51 U6A1.M9
M0_A_DQ45: U3.BG49 U6A1.M10
M0_A_DQ46: U3.BF48 U6A1.N10
M0_A_DQ47: U3.BD48 U6A1.P9
M0_A_DQ48: U3.BJ55 U6A1.B9
M0_A_DQ49: U3.BL55 U6A1.B11
M0_A_DQ50: U3.BJ53 U6A1.B10
M0_A_DQ51: U3.BL53 U6A1.C10
M0_A_DQ52: U3.BN55 U6A1.C11
M0_A_DQ53: U3.BN53 U6A1.C9
M0_A_DQ54: U3.BM52 U6A1.B8
M0_A_DQ55: U3.BK52 U6A1.C8
M0_A_DQ56: U3.BL51 U6A1.T9
M0_A_DQ57: U3.BJ51 U6A1.T8
M0_A_DQ58: U3.BL49 U6A1.R10
M0_A_DQ59: U3.BJ49 U6A1.R9
M0_A_DQ60: U3.BN49 U6A1.R11
M0_A_DQ61: U3.BN51 U6A1.R8
M0_A_DQ62: U3.BK48 U6A1.T10
M0_A_DQ63: U3.BM48 U6A1.T11
M0_A_DQSN0: U3.AJ61 U7A1.G11
M0_A_DQSN1: U3.AP62 U7A1.L11
M0_A_DQSN2: U3.AP56 U7A1.P11
M0_A_DQSN3: U3.AJ57 U7A1.D11
M0_A_DQSN4: U3.BD54 U6A1.G11
M0_A_DQSN5: U3.BF50 U6A1.L11
M0_A_DQSN6: U3.BM54 U6A1.D11
M0_A_DQSN7: U3.BK50 U6A1.P11
M0_A_DQSP0: U3.AJ63 U7A1.G10
M0_A_DQSP1: U3.AP60 U7A1.L10
M0_A_DQSP2: U3.AP58 U7A1.P10
M0_A_DQSP3: U3.AJ55 U7A1.D10
M0_A_DQSP4: U3.BF54 U6A1.G10
M0_A_DQSP5: U3.BD50 U6A1.L10
M0_A_DQSP6: U3.BK54 U6A1.D10
M0_A_DQSP7: U3.BM50 U6A1.P10
M0_A_ODT: U3.BN61 U6A1.J8 U7A1.J8
M0_A_ZQ0: R6L1.2 U7A1.B3
M0_A_ZQ1: R7A1.2 U7A1.B4
M0_B_A0: U3.BK59 U6A1.R2
M0_B_A1: U3.BL62 U6A1.P2
M0_B_A2: U3.BJ61 U6A1.N2
M0_B_A3: U3.AV60 U6A1.N3
M0_B_A4: U3.BN62 U6A1.M3
M0_B_A5: U3.BB61 U6A1.F3
M0_B_A6: U3.BL61 U6A1.E3
M0_B_A7: U3.BM59 U6A1.E2
M0_B_A8: U3.BN58 U6A1.D2
M0_B_A9: U3.AV62 U6A1.C2
M0_B_ZQ0: R6L3.2 U6A1.B3
M0_B_ZQ1: R6L2.2 U6A1.B4
M0_CKE0: U3.BB57 U6A1.K3 U7A1.K3
M0_CKE1: U3.BC58 U6A1.K4 U7A1.K4
M0_CS0_N: U3.AW63 U6A1.L3 U7A1.L3
M0_CS1_N: U3.BJ57 U6A1.L4 U7A1.L4
M1_A_A0: U3.BK30 U5A1.R2
M1_A_A1: U3.BN31 U5A1.P2
M1_A_A2: U3.BM32 U5A1.N2
M1_A_A3: U3.BL37 U5A1.N3
M1_A_A4: U3.BG31 U5A1.M3
M1_A_A5: U3.BN37 U5A1.F3
M1_A_A6: U3.BJ37 U5A1.E3
M1_A_A7: U3.BJ35 U5A1.E2
M1_A_A8: U3.BM34 U5A1.D2
M1_A_A9: U3.BN35 U5A1.C2
M1_A_CLKN0: U3.BK36 U5A1.J2
M1_A_CLKN1: U3.BD32 U4A1.J2
M1_A_CLKP0: U3.BM36 U5A1.J3
M1_A_CLKP1: U3.BF32 U4A1.J3
M1_A_DQ0: U3.BC41 U5A1.M11
M1_A_DQ1: U3.BC39 U5A1.P9
M1_A_DQ2: U3.BG41 U5A1.N10
M1_A_DQ3: U3.BE39 U5A1.N11
M1_A_DQ4: U3.BF42 U5A1.N9
M1_A_DQ5: U3.BD42 U5A1.M8
M1_A_DQ6: U3.BG39 U5A1.M10
M1_A_DQ7: U3.BE41 U5A1.M9
M1_A_DQ8: U3.BC43 U5A1.F10
M1_A_DQ9: U3.BD46 U5A1.D9
M1_A_DQ10: U3.BG43 U5A1.F9
M1_A_DQ11: U3.BG45 U5A1.F11
M1_A_DQ12: U3.BC45 U5A1.E9
M1_A_DQ13: U3.BE43 U5A1.F8
M1_A_DQ14: U3.BE45 U5A1.E10
M1_A_DQ15: U3.BF46 U5A1.E11
M1_A_DQ16: U3.BM28 U4A1.E9
M1_A_DQ17: U3.BN27 U4A1.F11
M1_A_DQ18: U3.BK28 U4A1.D9
M1_A_DQ19: U3.BL25 U4A1.F10
M1_A_DQ20: U3.BN25 U4A1.F9
M1_A_DQ21: U3.BL27 U4A1.E10
M1_A_DQ22: U3.BJ25 U4A1.F8
M1_A_DQ23: U3.BJ27 U4A1.E11
M1_A_DQ24: U3.BM24 U4A1.M8
M1_A_DQ25: U3.BK24 U4A1.P9
M1_A_DQ26: U3.BN21 U4A1.M11
M1_A_DQ27: U3.BJ23 U4A1.M10
M1_A_DQ28: U3.BL23 U4A1.N9
M1_A_DQ29: U3.BN23 U4A1.M9
M1_A_DQ30: U3.BJ21 U4A1.N10
M1_A_DQ31: U3.BL21 U4A1.N11
M1_A_DQ32: U3.BN45 U5A1.B11
M1_A_DQ33: U3.BM46 U5A1.B9
M1_A_DQ34: U3.BL43 U5A1.C10
M1_A_DQ35: U3.BK46 U5A1.B8
M1_A_DQ36: U3.BN43 U5A1.C9
M1_A_DQ37: U3.BL45 U5A1.C11
M1_A_DQ38: U3.BJ45 U5A1.B10
M1_A_DQ39: U3.BJ43 U5A1.C8
M1_A_DQ40: U3.BM42 U5A1.T8
M1_A_DQ41: U3.BN41 U5A1.R9
M1_A_DQ42: U3.BJ41 U5A1.R10
M1_A_DQ43: U3.BN39 U5A1.T11
M1_A_DQ44: U3.BK42 U5A1.R8
M1_A_DQ45: U3.BL41 U5A1.T9
M1_A_DQ46: U3.BL39 U5A1.R11
M1_A_DQ47: U3.BJ39 U5A1.T10
M1_A_DQ48: U3.BF28 U4A1.B9
M1_A_DQ49: U3.BD28 U4A1.B8
M1_A_DQ50: U3.BG25 U4A1.C10
M1_A_DQ51: U3.BC27 U4A1.C11
M1_A_DQ52: U3.BG27 U4A1.B11
M1_A_DQ53: U3.BE27 U4A1.B10
M1_A_DQ54: U3.BE25 U4A1.C9
M1_A_DQ55: U3.BC25 U4A1.C8
M1_A_DQ56: U3.BF24 U4A1.T8
M1_A_DQ57: U3.BD24 U4A1.R8
M1_A_DQ58: U3.BG21 U4A1.R11
M1_A_DQ59: U3.BC23 U4A1.T11
M1_A_DQ60: U3.BE23 U4A1.T9
M1_A_DQ61: U3.BG23 U4A1.R9
M1_A_DQ62: U3.BC21 U4A1.T10
M1_A_DQ63: U3.BE21 U4A1.R10
M1_A_DQSN0: U3.BD40 U5A1.L11
M1_A_DQSN1: U3.BD44 U5A1.G11
M1_A_DQSN2: U3.BK26 U4A1.G11
M1_A_DQSN3: U3.BM22 U4A1.L11
M1_A_DQSN4: U3.BK44 U5A1.D11
M1_A_DQSN5: U3.BM40 U5A1.P11
M1_A_DQSN6: U3.BD26 U4A1.D11
M1_A_DQSN7: U3.BF22 U4A1.P11
M1_A_DQSP0: U3.BF40 U5A1.L10
M1_A_DQSP1: U3.BF44 U5A1.G10
M1_A_DQSP2: U3.BM26 U4A1.G10
M1_A_DQSP3: U3.BK22 U4A1.L10
M1_A_DQSP4: U3.BM44 U5A1.D10
M1_A_DQSP5: U3.BK40 U5A1.P10
M1_A_DQSP6: U3.BF26 U4A1.D10
M1_A_DQSP7: U3.BD22 U4A1.P10
M1_A_ODT: U3.BC35 U4A1.J8 U5A1.J8
M1_A_ZQ0: R5L2.2 U5A1.B3
M1_A_ZQ1: R5L1.2 U5A1.B4
M1_B_A0: U3.BG37 U4A1.R2
M1_B_A1: U3.BE37 U4A1.P2
M1_B_A2: U3.BC37 U4A1.N2
M1_B_A3: U3.BF34 U4A1.N3
M1_B_A4: U3.BC33 U4A1.M3
M1_B_A5: U3.BF30 U4A1.F3
M1_B_A6: U3.BD36 U4A1.E3
M1_B_A7: U3.BG35 U4A1.E2
M1_B_A8: U3.BC31 U4A1.D2
M1_B_A9: U3.BF36 U4A1.C2
M1_B_ZQ0: R4L1.2 U4A1.B3
M1_B_ZQ1: R4L2.2 U4A1.B4
M1_CKE0: U3.BN33 U4A1.K3 U5A1.K3
M1_CKE1: U3.BK32 U4A1.K4 U5A1.K4
M1_CS0_N: U3.BM30 U4A1.L3 U5A1.L3
M1_CS1_N: U3.BJ33 U4A1.L4 U5A1.L4
MASTER_SCL: Q18.6 R260.2 R10980.2 U40.29
MASTER_SDA: Q18.3 R259.2 R10981.2 U40.28
MBCLK: PC220.2 PD3.1 PR239.1 PR309.2 Q6072.6 R341.1 R360.2 U17.B4
MBDATA: PC229.2 PD6.1 PR244.1 PR314.2 Q6072.3 R323.1 R331.2 U17.A2
ME_WR#: R244.1 U17.A3
MIC2-VREFO: R422.1 R447.1 U19.29
ML0N: C337.2 U13.10
ML0P: C351.2 U13.9
ML1N: C322.2 U13.13
ML1P: C328.2 U13.12
ML2N: C305.2 U13.16
ML2P: C309.2 U13.15
ML3N: C297.2 U13.19
ML3P: C301.2 U13.18
MOD_ID1: R10996.1 R10997.2 U40.27
MOD_ID2: R10994.2 R10995.2 U40.34
MPHY_EXT_PWR: R206.2 U3.BC7
MUTE_LED_EC: D36.1 R359.1 U17.A4
MX0: C411.1 CN11.3 U17.J12
MX1: C410.1 CN11.4 U17.J13
MX2: C409.1 CN11.5 U17.J9
MX3: C405.1 CN11.9 U17.H12
MX4: C398.1 CN11.16 U17.H9
MX5: C396.1 CN11.18 U17.H10
MX6: C395.1 CN11.19 U17.H13
MX7: C393.1 CN11.21 U17.G9
MY0: C408.1 CN11.6 U17.M8
MY1: C407.1 CN11.7 U17.J7
MY2: C406.1 CN11.8 U17.N9
MY3: C404.1 CN11.10 U17.M9
MY4: C403.1 CN11.11 U17.K8
MY5: C402.1 CN11.12 U17.J8
MY6: C401.1 CN11.13 U17.N10
MY7: C400.1 CN11.14 U17.M10
MY8: C399.1 CN11.15 U17.N11
MY9: C397.1 CN11.17 U17.K9
MY10: C394.1 CN11.20 U17.N12
MY11: C392.1 CN11.22 U17.N13
MY12: C391.1 CN11.23 U17.M13
MY13: C390.1 CN11.24 U17.L12
MY14: C389.1 CN11.25 U17.L13
MY15: C388.1 CN11.26 U17.K12
NB681_3V3_PRIM: PC148.1 PR222.1 PU11.10
NB681_3V3_VCCIO: PC55.1 PR38.1 PU7.10
NB681_VIN_PRIM: PC171.1 PC177.2 PC185.2 PR246.1 PU11.1
NB681_VIN_VCCIO: PC38.2 PC39.2 PC42.1 PR27.1 PU7.1
NB681BST_PRIM: PR196.1 PU11.9
NB681BST_VCCIO: PR145.1 PU7.9
NB681EN_PRIM: PC153.1 PR263.2 PR264.2 PU11.5
NB681EN_VCCIO: PC51.1 PR129.2 PR135.1 PU7.5
NB681PG_PRIM: PR231.1 PU11.13
NB681PG_VCCIO: PR33.1 PU7.13
NB681SW_PRIM: PC138.2 PL13.1 PR180.2 PU11.8
NB681SW_VCCIO: PC109.2 PL8.1 PR141.2 PU7.8
NB681VOUT_PRIM: PR57.1 PU11.12
NB681VOUT_VCCIO: PR165.1 PR169.2 PU7.12
NBSWON#: C470.2 CL1_CL2.2 PR71.1 PR491.1 R429.1 R490.1 SW3.3 SW3.4 U17.M11
NBSWON#_14_13: C358.2 CN10.6 CN11.1 R429.2
NO_REBOOT: R97.2 U3.BB4
NVDC#: PR115.1 PR124.2 PU5.H9
PANEL_CHRG_IN: CN6.6 U17.E7
PCBEEP: C356.1 U19.12
PCBEEP_EC: D19.2 U17.K7
PCH_MBCLK0: Q6066.3 R54.2 U3.AC12
PCH_MBCLK0_C: C428.2 CN12.5 D29.1 Q6066.4 R543.2
PCH_MBDAT0: Q6066.6 R52.2 U3.W6
PCH_MBDAT0_C: C418.2 CN12.6 D27.1 Q6066.1 R514.2
PCH_PCIE_WAKE#: R135.2 R201.2 U3.BP9
PCH_PWRBTN#: PR88.1 PU5.K2 R216.1
PCH_PWROK: PR150.1 PU5.E11 R214.2 R218.2 U17.D12
PCH_PWROK_R: C269.1 R218.1 R227.2 R501.2 U3.BP14
PCH_RSMRST#: R207.2 R208.2 R213.1 U3.BJ12
PCH_SLP_WLAN#: PR74.2 U3.BH16
PCH_SPI_CLK: R14.2 U3.AU10
PCH_SPI_CS0#: R5.1 R90.2 R326.2 U3.AU4
PCH_SPI_IO2: R15.2 R86.2 U3.AV11
PCH_SPI_IO3: R11.1 R75.2 U3.AV13
PCH_SPI_SI: R18.2 R77.2 U3.AT3
PCH_SPI_SO: R8.2 R87.2 U3.AU12
PCH_SUSPWRDNACK: R352.1 R10944.1 U17.A12
PCH_TRST#: R173.1 U3.C52
PCH_VRALERT#: R205.2 U3.BD6
PCIE_BIFURCATION0: T10.1 U3.D55
PCIE_BIFURCATION1: T6.1 U3.C56
PCIE_CLKREQ_WLAN#: Q12.3 R94.1 R194.2 U3.AV9
PCIE_RCOMPN: R35.2 U3.A9
PCIE_RCOMPP: R35.1 U3.B10
PCIE_STATIC: T15.1 U3.J52
PD#: C437.1 D35.2 D36.2 R432.2 R439.1 U19.47
PECI_R: R387.1 U17.B1
PEG TRAINING: T3.1 U3.F55
PGA: PR136.1 PU5.D6
PGB: PR94.1 PU5.C5
PGC: PR18.1 PU5.C6
PGD: PR89.1 PU5.H3
PGE: PR93.1 PU5.C4
PGF: PR97.1 PU5.H4
PGG: PR91.1 PU5.F3
PGVR4: PR95.1 PR104.2 PU5.B5
PGVR5: PR109.1 PR117.2 PU5.M4
PIRQA#: R113.1 R10970.1 U3.BF3
PLTRST#: C458.1 R96.2 U3.BB8 U17.M4
PM_BATLOW#: R204.2 U3.BD16
PM_NBSWON#: R216.2 R224.1 U3.BF14
PMIC_INT#: PR161.2 R409.2 U17.F10
PMIC_INT#_R: PR160.1 PR161.1 PU5.D12
PMIC_MBCLK: PR84.2 PU5.J1 Q6067.4 R10946.2
PMIC_MBCLK_R: Q6067.3 R353.2 R10946.1 U17.E8
PMIC_MBSDA: PR11.2 PU5.H1 Q6067.1 R10947.2
PMIC_MBSDA_R: Q6067.6 R358.2 R10947.1 U17.D7
PMON: PC187.2 PC211.2 PR249.1 PR256.1 PR282.1 PR286.1
POA_AUTH_ERR: CN17.7 U17.J10
POA_EN#: CN17.5 U17.K13
POA_FP_PWREN#: R10934.1 U17.E12
POA_POWERREQ: CN17.8 U17.N8
POA_PWR_INT#: CN17.6 R10944.2
POWER_ON_LED: R154.1 R155.1 U17.M5
PRIM_C0: PR227.1 PR236.2 PR342.2 PU11.4
PRIM_C1: PR243.2 PR251.1 PR341.2 PU11.3
PRIM_LP#: PR205.2 PR206.2 PU11.6
PSYS: PR286.2 PU12.50
PTP_PWR_EN#: R10941.1 U17.E2
PWM_SA: PR299.1 PU2.2
R_SPK+: C382.2 CN14.1 D26.1 U19.45
R_SPK-: C419.2 CN14.2 D25.1 U19.44
REGN6V: PC159.1 PR288.2 PU14.24
REXT_PS: R363.2 U13.2
RF_EN: CN1.56 R462.1
RING2: R422.2 R423.1 U19.17
RING2_R: C421.1 CN5.6 D28.1 R423.2
RSMRST#_PWRGD: PR159.1 PU5.J11 U17.C2
RSVD_BB14: R105.2 U3.BB14
RSVD_L20: R187.2 U3.L20
RTC_RST#: C24.1 C281.1 CL1_CL1.2 Q15.3 R95.2 U3.BN12
RTC_X1: C32.1 R131.1 U3.BN19 Y2.2
RTC_X2: C27.1 R131.2 U3.BP18 Y2.1
RXD: T68.1 U20.F2
SA0: R100.1 R101.1 U5.7
SATA_DEVSLP1: R32.1 R73.2 R10969.1 U3.F10
SATA_RXN: C149.2 U3.C26
SATA_RXN_C: C149.1 CN2.43
SATA_RXP: C160.2 U3.A26
SATA_RXP_C: C160.1 CN2.41
SATA_TXN: C134.2 U3.G26
SATA_TXN_C: C134.1 CN2.47
SATA_TXP: C114.2 U3.J26
SATA_TXP_C: C114.1 CN2.49
SCLK: PR269.1 PU12.38
SD_RCOMP: R84.1 U3.BF1
SDIO: PR254.2 PU12.36
SENSEA: R395.2 R418.2 U19.13
SENSOR_HUB_INT1#: Q27.3 R78.1 R391.2 R10968.1 U3.BD2
SENSOR_HUB_INT1#_Q: Q27.1 R390.1 R391.1 U20.E8
SERIRQ: R119.2 R10974.2 U3.BN8 U17.G2
SHUTDOWN#: PR120.2 PU4.3 PU5.C7 Q2.3 R230.1 U17.G1
SIO_EXT_SCI#: R29.2 R31.2 U17.N4
SIO_EXT_SCI#_R: R31.1 U3.F6
SIO_EXT_SMI#: R38.2 R43.2 U17.L2
SIO_EXT_SMI#_R: R43.1 U3.M7
SKTOCC#: T40.1 U3.B62
SLEEVE: R447.2 R448.1 U19.18
SLEEVE_R: C436.1 CN5.1 D31.1 R448.2
SLP_A#: T49.1 U3.BE17
SLP_S0#: PR40.1 PR62.2 PR111.1 PR132.1 PR206.1 PR210.2 U3.BC9
SLP_S3#: C376.1 PR65.2 PR127.1 PR129.1 PR134.1 PR198.2 PR493.2 U3.AY14 U17.D1
SLP_S4#: C441.1 PR14.1 PR64.1 PR98.1 PR114.1 PR138.1 PR199.2 U3.BF16 U17.N1 U39.10
SLP_S5#: T45.1 U3.BH14
SLP_SUS#: PR112.2 PR142.2 PR146.2 PR155.1 PR209.2 PR238.1 PR245.2 PR263.1 PR525.1 R232.2 R10949.2 U17.N2
SLP_SUS#_CPU: R232.1 U3.BN10
SLP_SUS#_DS3: R10948.1 R10949.1 R10961.1 U17.M12
SM_RCOMP_0: R127.2 U3.BF64
SM_RCOMP_1: R129.2 U3.BJ64
SM_RCOMP_2: R122.2 U3.BC64
SM_VREF_CA: C294.2 R279.1 U3.AR53
SM_VREF_DQ0: C194.2 R195.1 U3.AN53
SM_VREF_DQ1: C290.2 R263.1 U3.AW53
SMC: BAT1.6 PR309.1
SMCLK0: Q33.4 R455.1 R456.1 U20.G2
SMCLK4_ACC1: CN9.19 Q10.4 R169.1 R179.1 R382.1 R404.1 U5.4
SMCLK4_HUB: R382.2 R404.2 R411.2 U20.F9
SMD: BAT1.7 PR314.1
SMDAT0: Q33.1 R488.1 R489.1 U20.G1
SMDAT4_ACC1: CN9.20 Q10.1 R177.1 R184.1 R383.1 R405.1 U5.6
SMDAT4_HUB: R383.2 R405.2 R412.2 U20.E9
SML0_CLK: R188.1 U3.W4
SML0_DATA: R192.1 U3.AC10
SML0ALERT#: R55.2 U3.AA6
SML1_CLK: Q6064.4 R190.1 U3.AA4
SML1_DATA: Q6064.1 R191.1 U3.W10
SML1ALERT#: R103.2 U3.BB6
SMLALERT#: R189.2 U3.W8
SOC_DPST_PWM: R408.1 U3.B6
SOC_EDP_BLON: R281.2 R282.2 U3.D4 U17.B10
SOC_EDP_ENVDD: PR170.2 U3.D3
SPI_CLK: C3.1 R14.1 R16.2 U1.6
SPI_CS#: R1.2 R5.2 U1.1
SPI_IO2: R13.2 R15.1 U1.3
SPI_IO3: R6.1 R9.2 R11.2 U1.7
SPI_SI: R17.2 R18.1 U1.5
SPI_SO: R8.1 R10.2 U1.2
SRTC_RST#: C15.1 Q14.3 R89.2 U3.BH18
SSD_PEDET: T7.1 U3.G11
SSDE: R347.1 R366.1 U13.3
SSEQ: R318.1 R319.1 U13.11
SSRXN: C347.2 U13.4
SSRXP: C346.2 U13.5
SSTXN: C343.2 U13.7
SSTXP: C342.2 U13.8
SUSACK#_EC: R108.2 U17.F4
SUSACK#_EC_R: R108.1 R109.2 U3.BF9
SUSCLK: Q4.3 R63.1 R98.1 U3.BA15
SUSCLK_R: CN2.68 R63.2
SUSCLK_WLAN: CN1.50 Q4.1 R91.2
SUSLED#: R150.1 R153.1 U17.M6
SUSPWRDNACK#: R136.2 R352.2 R10961.2
SUSPWRDNACK#_R: R102.2 R109.1 R136.1 U3.BL6
SW0: R255.1 U13.21
SW1: R256.1 U13.22
SW2: R241.1 U13.23
SW_CORE: PC132.2 PL6.1 PQ6.9 PR34.2 PR164.2 PU12.24
SW_GT1: PC131.1 PL7.1 PQ7.9 PR36.2 PR163.2 PU12.16
SW_SA: PC18.2 PL3.1 PQ2.10 PR17.2 PR69.2 PU2.7
SWN_CORE: PR34.1 PR228.2
SWN_GT1: PR36.1 PR184.1 PR186.1
SWN_SA: PR17.1 PR295.1
SWVR1: PC105.2 PL9.1 PQ5.10 PR154.2 PU5.N11
SWVR3: PC106.2 PL5.1 PQ4.10 PR139.2 PU5.A11
SWVR4: PC86.2 PL1.1 PQ1.10 PR59.2 PU5.A3
SWVR5: PC92.2 PL2.1 PQ3.10 PR100.2 PU5.N2
SYS_I: PC231.1 PR279.1 U17.G13
SYS_PWROK: PR131.1 PU5.H11 R36.2 R41.2
SYS_PWROK_R: C4.1 R41.1 R42.2 U3.J1
SYS_RST#: R45.2 R10972.2 U3.H2
TEMP: BAT1.5 PR313.1
TEMP_ALERT#: PR87.1 PU5.L2
TEMP_MBAT#: PR304.2 PR312.1 PR313.2 U17.E13
THRMTRIP#: C2.1 Q2.1 R2.1 R172.1
TI_BFET#_TYPEC1: R283.2 U10.9
TI_BFET#_TYPEC2: R11003.2 U43.9
TOUCH_INT#: T17.1 U3.M9
TP_DDR0_ALERT#: T46.1 U3.BG57
TP_DDR0_PARITY: T50.1 U3.BM56
TPCLK: R441.1 R444.1 U17.D9
TPCLK_C: C430.2 CN12.3 CN16.7 D30.1 R441.2
TPD_EN: CN16.1 U17.C13
TPD_INT#: CN16.2 R10957.1 U3.AA10 U17.F2
TPDAT: R450.1 R451.1 U17.B9
TPDAT_C: C439.2 CN12.2 CN16.6 D32.1 R451.2
TS_EN: CN6.5 R338.1
TS_EN_EC: C349.1 R338.2 U17.C12
TSENSE_CORE: PC140.1 PR190.2 PU12.27
TSENSE_GT: PC147.1 PR203.2 PU12.11
TX1N: C299.1 U13.34
TX1P: C298.1 U13.33
TX2N: C313.1 U13.36
TX2P: C323.1 U13.37
TXD: T69.1 U20.F1
TYPEC1_CCG1_CC1: C947.2 CN3.A5 U4.9 U40.9
TYPEC1_CCG1_CC2: C948.2 CN3.B5 U4.1 U40.7
TYPEC1_CCG1_VBUS_C_CTRL: PR330.2 PR496.2 PU18.1 U40.12
TYPEC1_CCG1_VBUS_DISCHARGE: PQ15.5 PR324.2 U40.20
TYPEC1_CCG1_VBUS_P_CTRL: R265.1 R10962.2 U11.1 U40.11
TYPEC1_EN: Q29.2 R10987.2 U40.18
TYPEC1_SBU1: CN3.A8 U42.5
TYPEC1_SBU2: CN3.B8 U42.6
TYPEC1_USB0: C16.1 C17.1 C18.1 C19.1 C20.1 C306.1 CN3.A4 CN3.A9 CN3.B4 CN3.B9 D4.1 PD4.2 PD9.2 PQ14.5 PR310.1 R296.2 R297.2 R10988.2
TYPEC1_USB0_EN: R265.2 R274.2 R292.1 R10963.1 U10.2 U11.4
TYPEC1_USB0_R: Q19.5 Q19.6 Q19.7 Q19.8 R296.1 R297.1
TYPEC2_CCG1_CC1: C942.2 CN18.A5 U40.22 U42.9
TYPEC2_CCG1_CC2: C941.2 CN18.B5 U40.24 U42.1
TYPEC2_CCG4_VBUS_C_CTRL: PR500.2 PR502.2 PU20.1 U40.38
TYPEC2_CCG4_VBUS_DISCHARGE: PQ22.5 PR501.2 U40.40
TYPEC2_CCG4_VBUS_P_CTRL: R11007.2 R11009.1 U40.39 U44.1
TYPEC2_CCG_VBUS_C_CTRL_EC: PR498.2 PU20.2 U17.G12
TYPEC2_CCG_VBUS_P_CTRL_EC: R11016.2 U17.J4 U44.2
TYPEC2_OUT_1-5A: Q6071.2 R11005.2 U17.B13
TYPEC2_RX1N: CN18.B10 U13.31 U41.9
TYPEC2_RX1P: CN18.B11 U13.30 U41.1
TYPEC2_RX2N: CN18.A10 U13.39 U41.6
TYPEC2_RX2P: CN18.A11 U13.40 U41.5
TYPEC2_SBU1: CN18.A8 R11008.2 U13.27 U42.7
TYPEC2_SBU2: CN18.B8 R11019.2 U13.26 U42.4
TYPEC2_TX1N_C: C299.2 CN18.A3 U41.8
TYPEC2_TX1P_C: C298.2 CN18.A2 U41.2
TYPEC2_TX2N_C: C313.2 CN18.B3 U41.7
TYPEC2_TX2P_C: C323.2 CN18.B2 U41.4
TYPEC2_USB0: C960.1 C961.1 C962.1 C963.1 C964.1 C965.1 CN18.A4 CN18.A9 CN18.B4 CN18.B9 D51.1 PD11.2 PD13.2 PQ21.5 PR497.1 R10982.2 R11022.2 R11023.2
TYPEC2_USB0_EN: R11000.1 R11001.2 R11002.1 R11009.2 U43.2 U44.4
TYPEC2_USB0_R: Q6070.5 Q6070.6 Q6070.7 Q6070.8 R11022.1 R11023.1
TYPEC_CCG_VBUS_C_CTRL_EC: PR335.2 PU18.2 U17.F13
TYPEC_CCG_VBUS_P_CTRL_EC: R243.2 U11.2 U17.E1
TYPEC_DDI1_HPD_CPU: Q8.1 R142.1 R144.2 U3.C11
TYPEC_DDI2_HPD: Q8.3 R142.2 R143.2 R10985.2 U13.32 U40.30
TYPEC_OUT_1-5A: Q20.2 R264.2 U17.N3
UART2_RXD: T25.1 U3.AD5
UART2_TXD: T23.1 U3.AD7
USB3_RXN2: C347.1 U3.B15
USB3_RXN2_B1-: CN3.A10 U8.6 U15.16
USB3_RXN2_C1-: CN3.B10 U8.9 U15.12
USB3_RXN2_RE_C2: U14.5 U15.8
USB3_RXN3: C339.1 U3.C16
USB3_RXN3_C: C339.2 U14.7
USB3_RXP2: C346.1 U3.D15
USB3_RXP2_B1+: CN3.A11 U8.5 U15.17
USB3_RXP2_C1+: CN3.B11 U8.1 U15.13
USB3_RXP2_RE_C2: U14.4 U15.7
USB3_RXP3: C333.1 U3.A16
USB3_RXP3_C: C333.2 U14.8
USB3_TXN2: C343.1 U3.F15
USB3_TXN2_B0-: C362.2 U15.18
USB3_TXN2_B0-_R: C362.1 CN3.B3 U8.7
USB3_TXN2_C0-: C336.2 U15.14
USB3_TXN2_C0-_R: C336.1 CN3.A3 U8.8
USB3_TXN2_RE_C2: U14.2 U15.4
USB3_TXN3: C327.1 U3.G16
USB3_TXN3_C: C327.2 U14.10
USB3_TXP2: C342.1 U3.H15
USB3_TXP2_B0+: C372.2 U15.19
USB3_TXP2_B0+_R: C372.1 CN3.B2 U8.4
USB3_TXP2_C0+: C340.2 U15.15
USB3_TXP2_C0+_R: C340.1 CN3.A2 U8.2
USB3_TXP2_RE_C2: U14.1 U15.3
USB3_TXP3: C318.1 U3.J16
USB3_TXP3_C: C318.2 U14.11
USB_BIAS: R53.1 U3.N2
USBOC01#: R51.1 U3.N12
USBOC23#: R46.1 U3.M11
USBOC45#: R33.1 U3.F8
USBP1+_POA: R1526.1 R1531.2 U3.AL4
USBP1+_POA_R: CN17.2 D49.2 R1528.2 R1533.1
USBP1+_POA_R2: R1533.2 U39.7
USBP1+_POA_R3: R1526.2 R1528.1
USBP1+_POA_U: R1531.1 U39.1
USBP1-_POA: R1527.1 R1532.2 U3.AL6
USBP1-_POA_R: CN17.3 D50.2 R1529.2 R1534.1
USBP1-_POA_R2: R1534.2 U39.6
USBP1-_POA_R3: R1527.2 R1529.1
USBP1-_POA_U: R1532.1 U39.2
USBP2+: CN18.A6 CN18.B6 U3.AH3 U42.2
USBP2-: CN18.A7 CN18.B7 U3.AH5 U42.8
USBP3+: CN3.A6 CN3.B6 U3.AJ4 U4.6
USBP3-: CN3.A7 CN3.B7 U3.AJ6 U4.5
USBP4+: R327.2 U3.AF3
USBP4+_L_13: CN8.3 D16.1 R327.1
USBP4-: R335.2 U3.AF5
USBP4-_L_13: CN8.2 D17.1 R335.1
USBP5+: R162.2 U3.AM5
USBP5+_L: CN6.2 D14.1 R162.1
USBP5-: R165.2 U3.AM3
USBP5-_L: CN6.3 D15.1 R165.1
USBP6+: CN1.3 U3.AG4
USBP6-: CN1.5 U3.AG6
VBSTVR1: PR137.2 PU5.M11
VBSTVR3: PR144.2 PU5.B11
VBSTVR4: PR66.2 PU5.B3
VBSTVR5: PR106.2 PU5.M3
VCONN_5V_P1: U16.5 U16.6 U40.8 U40.19
VCONN_5V_P2: U18.5 U18.6 U40.23 U40.25
VCORE: C51.1 C52.1 C53.1 C57.1 C70.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C86.1 C89.2 C93.1 C95.2 C107.2 C111.1 C115.1 C127.1 C129.2 C130.1 C135.2 C140.1 C145.1 C146.2 C148.2 C151.1 C158.1 C164.1 C169.2 C179.1 C182.1 C192.1 C193.2 C202.1 C203.1 C212.1 C213.1 C489.1 C490.1 C491.1 PC104.1 PL6.2 PR35.2 PR81.1 U3.A64 U3.AA32 U3.AA41 U3.AC32 U3.AC41 U3.AE32 U3.AE33 U3.AE35 U3.AE36 U3.AE38 U3.AE40 U3.AE41 U3.AF32 U3.AF41 U3.AH32 U3.AH41 U3.AK32 U3.AK41 U3.AL32 U3.AL41 U3.AN32 U3.AN41 U3.AR32 U3.AR41 U3.AT32 U3.AT33 U3.AT35 U3.AT36 U3.AT38 U3.AT40 U3.AT41 U3.B64 U3.D64 U3.F64 U3.H63 U3.J64 U3.L40 U3.L42 U3.L44 U3.L46 U3.L48 U3.L50 U3.L52 U3.L54 U3.L63 U3.M33 U3.M35 U3.M37 U3.M39 U3.M41 U3.M43 U3.M45 U3.M47 U3.M49 U3.M51 U3.M53 U3.M56 U3.M58 U3.M60 U3.M62 U3.M64 U3.N32 U3.N34 U3.N36 U3.N38 U3.N40 U3.N42 U3.N54 U3.N55 U3.N57 U3.N59 U3.N61 U3.N63 U3.P56 U3.P58 U3.P60 U3.P62 U3.P64 U3.R32 U3.R41 U3.R57 U3.R59 U3.R61 U3.R63 U3.T32 U3.T41 U3.V32 U3.V41 U3.Y32 U3.Y41
VCORE_SVID_ALERT#: PR259.1 PR267.2 R167.2 R170.2
VCORE_SVID_CLK: PR269.2 PR272.2 U3.A56
VCORE_SVID_DATA: PR254.1 PR257.1 R166.1 U3.A58
VGTA_BST1: PC18.1 PU2.1
VOLUME-DOWN: CN10.2 U17.M7
VOLUME-UP: CN10.4 U17.J6
VOUT3.3VSW: PC99.1 PU5.M7
VOUTLDO: PC52.1 PR41.2 PR125.1 PU5.A8 PU5.B8
VPROGOTP: PR92.1 PU5.D3
VR_EN: PR297.2 PR298.2 PU12.41
VR_HOT#: PR265.2 PU12.35
VR_RDY: PR294.2 PU12.42
VREF1.25V: PC27.1 PU5.B1
VRMP: PC141.2 PR194.1 PU12.12
VRON: PR492.2 U17.F9
VRON_R: PR298.1 PR494.2 PR495.1 PU19.4
VSN_CORE: PC144.2 PR200.1 PU12.29
VSN_GT: PC200.1 PR275.1 PU12.52
VSN_SA: PC196.2 PR296.1 PU12.48
VSP_CORE: PR193.1 PR197.1 PU12.28
VSP_GT: PC202.1 PR285.2 PU12.51
VSP_SA: PC195.2 PR284.2 PU12.49
VSTBY_FSPI: D22.1 PD2.1 PQ8.1 PQ9.4 PR15.1 PR24.2 PU18.5 PU20.5 R3.1 R47.1 R250.1 R275.2 R291.1 R314.1 R320.1 R321.1 R330.1 R331.1 R345.1 R353.1 R358.1 R359.2 R360.1 R361.1 R368.2 R370.2 R378.1 R384.1 R386.1 R389.1 R409.1 R483.1 R490.2 R10932.2 R10952.2 U11.5 U44.5
VSTBY_FSPI_R: C310.1 C311.1 C330.1 C331.1 C334.1 C335.1 R370.1 R392.1 U17.D4 U17.D5 U17.D10 U17.E4 U17.E9 U17.K4 U17.K10
WAKE_WLAN#: CN1.55 Q13.1 R202.2
WIFI_RF_KILL#_R: C433.1 R462.2 U17.G10
WLAN_EN: PC89.1 PR70.1 PR74.1 PU3.3
WLAN_PCIE_RXN9: CN1.43 U3.C28
WLAN_PCIE_RXP9: CN1.41 U3.A28
WLAN_PCIE_TXN9: C126.2 U3.G28
WLAN_PCIE_TXN9_C: C126.1 CN1.37
WLAN_PCIE_TXP9: C109.2 U3.J28
WLAN_PCIE_TXP9_C: C109.1 CN1.35
WLAN_RST#: CN1.52 R96.1
WRST#_8350: C412.1 D21.2 R413.1 U20.H9
XCLK_BIASREF: R50.1 U3.P1
XDP_BPM0: T5.1 U3.H51
XDP_BPM1: T14.1 U3.J50
XDP_BPM2: T2.1 U3.F51
XDP_BPM3: T39.1 U3.G50
XDP_CPU_TRST#: R173.2 U3.F47
XDP_PRDY#: T9.1 U3.D51
XDP_PREQ#: T13.1 U3.B55
XDP_TCK_CPU: R19.2 R20.1 U3.D53
XDP_TDI: R26.1 U3.C50
XDP_TDI_CPU: R26.2 U3.C54
XDP_TDO: R24.2 R25.1 U3.B51
XDP_TDO_CPU: R24.1 U3.G48
XDP_TMS: R21.2 U3.A52
XDP_TMS_CPU: R21.1 U3.C59
XTAL24_IN: C11.1 R49.1 U3.M1 Y1.1
XTAL24_OUT: C10.1 R49.2 U3.L2 Y1.3
N16995392: R118.2 U3.BL10
N17028320: C245.2 R10965.1 U3.BA39
N17308324: PR326.2 PR328.2 PR330.1 PU18.4
N17389829: R99.1 R102.1 R135.1 R203.1 R204.1 R502.2 R503.2
N17400952: R125.2 U3.BN17
N17400953: R126.2 U3.BP16
N17402934: T35.1 U3.BJ15
N17402948: T52.1 U3.BJ17
N17796697: R269.1 U13.29
N17797616: Q18.1 R255.2 R260.1 R266.2
N17797655: Q18.4 R256.2 R259.1 R273.2
N17838884: C338.1 U13.1
N18498938: CN2.56 T22.1
N18498955: CN2.58 T18.1
N18538001: PQ15.2 PR326.1
N18566125: PQ14.4 PQ17.4 PR318.2 PR321.1
N18566975: PQ15.6 PR318.1
N18652907: PC105.1 PR137.1
N18652998: PC107.1 PR154.1
N18653022: PC102.1 PR139.1
N18653045: PC106.1 PR144.1
N18653149: PL10.1 PU5.H12 PU5.H13
N18656165: PC86.1 PR66.1
N18656336: PC92.1 PR106.1
N18656394: PC87.1 PR59.1
N18656412: PR83.1 PU5.E3
N18659407: PR134.2 PU5.J12
N18660009: PR77.2 PU5.E6
N18660011: PR13.2 PU5.E7
N18660013: PR45.2 PU5.K9
N18660028: PR101.2 PR102.2 PU5.K3
N18660067: PR85.1 PR86.1 PU5.L3
N18660148: PR162.2 PU5.B13
N18660150: PR162.1 T42.1
N18660152: PR43.2 PU5.N5
N18660154: PR132.2 PU5.D9
N18660156: PR10.2 PR15.2 PU5.L1
N18660158: PR71.2 PU5.H2
N18660187: PR156.1 PU5.L12
N18660199: PR138.2 PU5.C11
N18660234: PR127.2 PU5.B10
N18660242: PR105.2 PR108.1 PU5.G3
N18660280: PR116.2 PU5.L6
N18660346: PR103.2 PU5.J4
N18660605: PR147.2 PU5.J10
N18660635: PR76.2 PU5.E8
N18660683: PR12.2 PU5.F4
N18660779: PR155.2 PU5.F10
N18663981: PR20.2 PR232.2 PR240.2
N18663989: PC142.2 PC144.1 PR191.2 PR200.2
N18663991: PC139.1 PR182.1 PU12.13
N18664007: PC143.2 PR197.2
N18664028: PC142.1 PC143.1 PR192.2 PR193.2
N18664596: PC115.2 PR164.1
N18664891: PC195.1 PC210.1 PR284.1 PR301.2
N18664913: PC196.1 PC210.2 PR296.2 PR302.2
N18665779: PC111.2 PR163.1
N18665845: PR56.2 PR201.1 PR203.1
N18665924: PC149.1 PR207.1
N18665958: PR21.1 PR237.2
N18666070: PR53.2 PR189.1 PR190.1
N18666111: PC182.2 PR248.1
N18666125: PC174.2 PR253.1
N18666311: PR258.2 PU12.39
N18666325: PR299.2 PR300.2 PU12.40
N18666410: PC197.1 PR281.1
N18666460: PR28.1 PR293.2
N18666488: PC200.2 PC202.2 PR275.2 PR287.2
N18668050: PC88.2 PR69.1
N18668099: PR5.2 PU2.3
N18673106: PC172.1 PU13.12
N18673108: PC176.1 PU13.10
N18673146: PC179.1 PR245.1 PR250.1 PU13.5
N18673154: PC170.1 PR230.2 PR238.2 PU13.3
N18673222: PC2.1 PU1.12
N18673224: PC3.1 PU1.10
N18673340: PC29.1 PU3.12
N18673342: PC35.1 PU3.10
N18677978: PC60.1 PU6.12
N18677980: PC59.1 PU6.10
N18731575: C353.2 R367.2
N18731881: R392.2 U17.E6
N18772040: PC117.1 PU9.3 PU10.4
N18772327: PC135.1 PU9.12
N18772329: PC136.1 PU9.10
N18772365: PC119.1 PR170.1 PU9.5
N18961519: T16.1 U3.E11
N18961543: T32.1 U3.BD8
N19176144: PR149.2 PU5.B12
N19270898: PQ14.1 PQ14.2 PQ14.3 PQ17.1 PQ17.2 PQ17.3 PR321.2
N19319857: T11.1 U3.J34
N19319860: T12.1 U3.G34
N19738745: C282.1 R295.1 U13.17
N19967862: PC91.1 PR98.2 PU3.5
N19970589: PC84.1 PR63.2 PR64.2 PU1.5
N19971810: PR62.1 PU8.1
N19971812: PR65.1 PU8.2
N19971816: PC82.1 PU1.3 PU8.4
N19975647: PC223.1 PR311.2 PU16.1
N19975655: PC232.1 PQ16.3 PR319.2 PR320.2 PU16.3
N19975671: PD4.1 PD13.1 PR311.1 PR319.1
N19975677: PQ9.6 PR217.1 PR226.1 PR229.1
N19975679: PQ9.5 PR217.2
N19975685: PQ9.1 PR214.1 PR220.1
N19975689: PQ9.2 PR229.2
N19975719: PQ8.3 PR211.1 PR223.1
N19975741: PR315.1 PR317.1 PU16.4
N19975767: PC235.2 PR327.1 PU17.1
N19975775: PD9.1 PR327.2 PR331.1
N19975781: PR325.1 PR332.1 PU17.4
N19975811: PC237.1 PQ19.3 PR331.2 PR334.1 PU17.3
N20047552: PQ15.3 PR310.2
N20069111: PC98.1 PR111.2 PR114.2 PU6.3
N20070147: PC96.1 PR112.1 PR113.1 PU6.5
N20234754: Q13.3 R199.1 R201.1
N20274642: T21.1 U3.V5
N20444921: C300.1 U10.1
N20445116: C302.2 Q19.4 R283.1
N20445118: R299.1 R300.1 U10.10
N20445227: Q20.3 R299.2
N20543374: T33.1 U5.9
N20552780: PR31.2 PU4.1
N20557258: C288.2 Q16.2 Q16.3 R249.2
N20557273: R249.1 R250.2 R251.2
N20557304: Q17.3 R240.2 SW2.1 SW2.2
N20610181: C451.2 U19.39
N20610208: C434.1 U19.19
N20610240: TP3.1 U19.48
N20610439: C371.1 U19.7
N20610561: D19.1 D20.1 R346.2
N20610622: R393.2 U19.20
N20614892: R492.2 R495.2 U21.5
N20615024: D35.1 Q34.3
N20616946: Q30.2 R425.2 R433.1
N20616966: Q28.2 Q30.3 R380.2
N20651243: PR305.1 PR307.2 PU15.4
N20651340: PR306.1 PU15.5
N20651346: PC161.1 PR235.1 PU15.6
N20690993: PC152.1 PR218.1
N20691009: PR234.2 PU14.13
N20691013: PD7.1 PR292.2
N20691066: PR256.2 PU14.9
N20691132: PC218.1 PQ12.4 PR308.1
N20691268: PC190.1 PR266.1 T56.1
N20919304: D7.1 LED5.2 R158.2
N20919308: D6.1 LED5.1 R157.2
N21172005: T24.1 U3.AC8
N21172007: T19.1 U3.AA8
N21220914: C381.2 U20.G9
N22084354: Q2.2 R12.2
N22084365: Q1.1 R12.1
N22351810: D13.1 LED6.2 R155.2
N22351814: D8.1 LED6.1 R150.2
N22588420: T8.1 U3.L6
N22605730: T30.1 U3.AW8
N22608461: T1.1 U3.G52
N22656295: C194.1 R193.2
N22656325: C294.1 R280.2
N22657187: C290.1 R247.2
N22911521: PR47.2 PU7.7
N22911634: PR167.2 PR168.2
N22911638: PR165.2 PR166.1
N22912068: PC100.2 PR141.1
N22925492: PC109.1 PR145.2
N22926183: PC138.1 PR196.2
N22926200: PC128.2 PR180.1
N22926247: PR195.2 PU11.7
N22955196: PR54.2 PU5.K8
N22955327: PR19.2 PU5.F5
N22981973: C2.2 R7.2
N22982990: C458.2 R482.2
N22983074: C4.2 R37.2
N22983255: C269.2 R222.2
N22983553: C281.2 R236.2
N23037532: C7.1 D2.2 MR1.1 R39.2 R47.2 R48.2
N23038330: R230.2 U9.7
N23038357: C295.1 R290.2 R291.2 R505.2 U9.1
N23086485: PR198.1 PR199.1 PU10.2
N23086491: PR209.1 PR210.1 PU10.1
N23207919: PR44.2 PU5.L11
N23253258: D10.1 LED1.1 R152.2
N23253306: D9.1 LED3.1 R151.2
N23253357: D12.1 LED2.1 R154.2
N23253403: D11.1 LED4.1 R153.2
N24084686: PR492.1 PR494.1 PU19.1
N24084688: PR493.1 PU19.2
N24184609: D39.2 R10951.1 R10952.1
N24462115: C927.2 Q6062.2 R10934.2
N24462247: R10930.1 U39.9
N24462291: R659.2 U39.8
N24462338: TP88.1 U39.4
N24462340: TP89.1 U39.5
N24465197: C725.1 Q6063.2 R10941.2
N24583116: Q6068.3 R10963.2
N25078903: PR499.2 PR502.1 PR505.2 PU20.4
N25078905: PQ22.2 PR505.1
N25078919: PQ20.4 PQ21.4 PR503.2 PR504.1
N25078922: PQ22.6 PR503.1
N25078926: PQ20.1 PQ20.2 PQ20.3 PQ21.1 PQ21.2 PQ21.3 PR504.2
N25078939: PQ22.3 PR497.2
N25079793: PC243.2 PR515.2 PU21.1
N25079799: PR507.1 PR516.1 PU21.4
N25079813: PD11.1 PR515.1 PR517.1
N25079814: PC242.1 PQ28.3 PR508.1 PR517.2 PU21.3
N25079824: PQ23.6 PR506.1 PR512.1 PR514.1
N25079825: PQ23.5 PR514.2
N25079829: PQ23.2 PR506.2
N25079843: PQ23.1 PR509.1
N25079845: PQ24.1 PR25.1
N25083539: TP24.1 U40.21
N25083553: TP38.1 U40.36
N25083555: TP39.1 U40.35
N25083703: C943.2 R10982.1 R10983.1 U40.37
N25083859: TP23.1 U40.14
N25084052: C949.1 U40.33
N25084056: C944.2 R10988.1 R10991.1 U40.13
N25084134: TP29.1 U40.4
N25084136: TP30.1 U40.3
N25084209: TP28.1 U40.5
N25084211: TP26.1 U40.6
N25086176: Q6069.3 R11000.2
N25086276: C959.2 Q6070.4 R11003.1
N25086302: C955.1 U43.1
N25086480: R11004.1 R11006.1 U43.10
N25086597: Q6071.3 R11006.2
N25118502: PQ26.6 PR519.1 PR520.1 PR523.1
N25118504: PQ26.5 PR520.2
N25118512: PQ26.2 PR519.2
N25118541: PQ26.1 PR521.1
N25118545: PQ27.1 PR522.1
N25191021: PC251.1 PR525.2 PU22.3
N25201896: PC245.1 PU22.12
N25653242: R117.2 U16.3
N25653896: R121.2 U18.3
N187300890: C456.1 U17.K5
N262237880: PC94.1 PR100.1
N262255820: PU5.M6 T20.1

Pads without a net: CN1 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 58 59 60 61 62 65 67; CN2 5 6 7 8 9 11 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 59 60 61 62 63 64 65 66 67; CN6 9 10; CN7 1 3 4 8 9 10; CN8 6; CN9 26 27 28 29; NOREF#5 1; NOREF#6 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; NOREF#11 1; PU5 A1 A13 C8 F2 G2 H10 J2 K11 K13 L10 N1 N13; PU12 20 21 22; PU14 14; PU15 1 9; PU22 5 6 7 8 9 10; U3 A18 A20 A22 A24 A30 A32 A34 A36 A38 A40 A42 A44 AA12 AB5 AB7 AC4 AC6 AD3 AD9 AE6 AF7 AH7 AJ8 AJ10 AJ12 AL8 AL10 AL12 AM7 AM9 AM11 AN4 AN6 AN8 AN10 AN12 AP3 AP5 AP7 AP9 AP11 AT5 AT7 AT9 AT11 AT13 AU6 AU8 AV5 AV7 AW4 AW6 AW10 AW12 AW61 AY18 AY20 AY22 B3 B4 B12 B17 B19 B21 B23 B25 B27 B29 B31 B33 B35 B37 B39 B41 B43 BA17 BA19 BA21 BA23 BB2 BB10 BB16 BB18 BC3 BC5 BC11 BC15 BC19 BD10 BD18 BD30 BD34 BE19 BE57 BF7 BF18 BG33 BG47 BH30 BK14 BL4 BL12 BL17 BL64 BN1 BN3 BN4 BP3 BP11 BP20 C18 C20 C22 C24 C30 C32 C34 C36 C38 C42 C44 D12 D17 D19 D21 D23 D25 D27 D29 D31 D33 D35 D37 D39 D41 D43 D49 D57 D61 F1 F3 F12 F17 F19 F21 F23 F25 F27 F29 F31 F33 F37 F39 F43 F53 F61 G18 G20 G22 G24 G30 G32 G36 G38 G40 G46 G54 G56 G58 H4 H8 H10 H12 H17 H19 H21 H23 H25 H27 H29 H31 H33 H37 H39 H43 H53 H59 H61 J11 J18 J20 J22 J24 J30 J32 J36 J38 J40 J46 J54 J56 J58 J60 K12 L4 L8 L10 L16 L18 L22 L24 L26 L28 L36 L38 M5 M15 M17 M19 M21 M23 M25 M27 N6 N8 N10 P3 P9 P11 P13 R12 T3 T5 T7 T9 T11 U4 U6 U8 U10 U12 V3 V7 V9 V11 W12; U4 2 4 7 8; U4A1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; U5 2 3; U5A1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; U6A1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; U7A1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; U9 8; U16 4 7; U18 4 7; U19 14 15 16 23 24; U20 A1 A7 A8 A9 B1 B2 B7 B8 B9 C2 C8 C9 D1 D2 D8 D9 E1 G8 H3 H4 H5 H6 H7 H8 J2 J3 J4 J5 J6 J7 J8 J9

## Via types
v1: diameter 0.254, hole 0.102, TOP to IN1, 1017 vias
v2: diameter 0.254, hole 0.102, IN1 to GND1, 876 vias
v3: diameter 0.254, hole 0.102, GND1 to IN2, 334 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 2110 vias
v5: diameter 0.61, hole 0.356, TOP to BOTTOM, 580 vias
v6: diameter 0.22, hole 0.102, IN3 to GND2, 85 vias
v7: diameter 0.254, hole 0.102, GND2 to IN4, 1297 vias
v8: diameter 0.254, hole 0.102, IN4 to BOTTOM, 1431 vias
v9: diameter 0.406, hole 0.203, GND1 to GND2, 572 vias
v10: diameter 0.254, hole 0.102, IN3 to GND2, 287 vias
v11: diameter 0.22, hole 0.102, TOP to IN1, 391 vias
v12: diameter 0.22, hole 0.102, IN1 to GND1, 202 vias
v13: diameter 0.457, hole 0.254, TOP to BOTTOM, 459 vias
v14: diameter 0.22, hole 0.102, GND1 to IN2, 112 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+1.5V: length 199.5
  TOP w0.381: 239.44,12.5 239.97,12.5 241.93,14.46 247.01,14.46 v4(247.79,15.24)
  TOP w0.508: v4(216.15,11.28) 216.59,11.73 222.94,11.73 225.42,14.21 237.74,14.21 239.44,12.5 239.44,6.74 v4(239.95,6.23)
  IN2 w0.381: v4(100.86,26.27) 100.86,25.63 98.31,23.08 98.31,16.43 104.12,10.62 125.06,10.62 127.37,12.94 130.91,12.94 131.41,12.43 147.44,12.43 147.57,12.3 v4(147.57,11.95)
  IN2 w0.508: v4(179.06,9.51) 179.06,5.27 v4(179.83,4.5) 180.38,5.06 185.29,5.06 185.54,4.81 187.32,4.81 187.85,5.34 197.2,5.34 197.99,4.55 199.89,4.55 205.23,9.89 212.46,9.89 213.35,10.78 213.99,10.78 214.17,10.6 215.08,10.6 215.77,11.28 v4(216.15,11.28)
  IN4 w0.381: v4(179.06,9.51) 178.73,9.84 173.09,9.84 172.64,9.38 171.06,9.38 169.65,10.79 163.84,10.79 162.91,11.72 162.71,11.72 162,12.43 161.59,12.43 161.28,12.12 161.28,12.02 161.03,11.77 160.01,11.77 159.86,11.92 151.84,11.92 151.3,11.39 147.84,11.39 147.57,11.67 v4(147.57,11.95)
  BOTTOM w0.381: v4(247.79,15.24) 247.71,15.32 R374.2 ; R219.2 111.26,32.87 v4(108.87,30.48) 108.15,29.75 104.62,29.75 v4(104.3,29.44) 103.88,29.01 103.88,27.79 102.36,26.27 v4(100.86,26.27)
+1.5VA: length 5.5
  BOTTOM w0.203: U19.40 244.15,7.47 243.83,7.15 C440.1 243.15,6.82 242.98,6.65 C445.1 242.49,5.87 241.26,5.87 v4(241.23,5.91) L11.1
+3.3V_TYPEC_MUX: length 22.4
  IN3 w0.305: v8(254.25,18.24) 255.21,18.24 v8(256.63,19.67)
  IN3 w0.381: v8(254.25,18.24) 254.25,19.21 v4(253.28,20.17) 256.33,23.22 v4(256.63,23.22)
  BOTTOM w0.117: U13.6 250.78,18.86 250.49,18.58 C345.1
  BOTTOM w0.203: v4(247.24,24.92) 247.24,24.75 247.49,24.49 R295.2 ; v4(249.55,28.94) 249.32,28.71 R241.2 ; v4(245.74,22.33) 246.02,22.33 246.25,22.11 R304.2 ; v4(245.74,20.17) 246.02,20.46 R318.2 ; R10950.1 252.47,28.81 v4(252.34,28.94) ; R303.2 v4(256.63,23.22)
  BOTTOM w0.254: Q18.5 Q18.2 230.12,27.54 230.42,27.85 231.59,27.85
  BOTTOM w0.508: v4(248.94,18.52) 249.37,18.08 C344.1 C345.1
  vias: v4(232.91,18.65) v4(233.04,26.78) v4(233.42,18.27) v4(234.31,21.32) v4(241.98,19.67) v4(245.87,27.41) v4(246.5,27.41) v4(253.74,27.29) v4(253.99,27.92)
+3V: length 289
  TOP w0.203: R78.2 104.31,41.04 104.28,41.01 R83.1 103.91,41.01 103.47,40.57 v2(103.47,40.33) ; v4(97.23,44.16) 97.38,44 R60.2 R66.2 ; v4(83.31,37) 83.31,38.21 83.48,38.38 R100.2 ; R113.2 102.87,35.75 ; 102.87,35.75 102.71,35.59 v2(102.51,35.59) 102.22,35.59 R114.1 ; 102.87,35.75 R119.1 ; R32.2 108.65,53.14 108.27,53.53 104.95,53.53 104.59,53.17 R28.1 R27.1 103.27,52.97 103.17,52.86 v4(103.17,52.56) 103.68,52.05 103.68,51.34 103.47,51.14 103.47,49.84 R45.1 ; v2(101.39,36.76) 101.29,36.66 R110.1 ; v2(100.17,38.26) 100.2,38.28 R97.1 R94.2
  TOP w0.254: v4(182.49,15.48) 182.49,16.04 181.81,16.72 181.81,19.01 185.38,22.59 187.98,22.59 188.89,23.5 188.89,28.46 191.48,31.05 191.5,31.05 v4(191.51,31.05)
  TOP w0.508: R88.1 v4(42.09,38.89) ; v4(249.83,16.17) 251.31,14.68 252.48,14.68 252.83,15.03 v4(252.83,15.26) 252.83,17.36 254.58,19.11 v4(254.58,29.95) 254.58,31.15 v4(254.25,31.48)
  IN1 w0.508: v4(254.25,31.48) v4(252.6,31.48) 252.04,31.48 v4(250.92,32.6) ; v4(252.83,15.26) 252.82,15.25 252.82,15.02 252.39,14.6 250.82,14.6 249.85,13.63 245.26,13.63 244.98,13.92 v4(244.06,13.92) 244.06,13.67 242.94,12.55 240.35,12.55 239.97,12.17 235.32,12.17 234.94,11.79 v4(232.18,11.79) 227.7,11.79 226.94,12.55 226.15,12.55 224.4,10.8 221.38,10.8 220.14,9.56 215.61,9.56 215.39,9.33 215.39,4.2 213.77,2.58 189.04,2.58
  GND1 w0.254: v2(102.51,35.59) 102.25,35.59 102.05,35.8 101.69,35.8 101.21,36.28 v9(101.21,36.38) 101.21,36.58 v2(101.39,36.76) ; v2(100.17,38.26) 100.17,38.01 v9(100.09,37.93) ; v9(103.29,39.53) 103.47,39.71 v2(103.47,40.33)
  IN2 w0.203: v9(70.4,51.32) 70.38,51.32 70.04,51.65 v3(68.12,51.65)
  IN3 w0.203: v9(70.4,51.32) 71.02,51.32 71.57,50.76 71.57,50.57 71.98,50.16 72.23,50.16 72.32,50.25 73.41,50.25 75.01,48.64 75.01,47.98 74.63,47.6 74.53,47.6 73.28,46.35 73.28,44.8 73.58,44.51 73.58,44.3 74.09,43.8 74.09,41.33 73.17,40.42 v8(73.17,40.05)
  IN3 w0.254: v8(178.96,14.41) 178.99,14.43 181.55,14.43 182.49,15.37 v4(182.49,15.48) ; v8(73.17,40.05) 72.79,40.43 72.36,40.43 72.28,40.35 71.64,40.35 v9(71.32,40.67)
  IN3 w0.508: 39.24,14.49 44.23,9.5 44.23,7.17 45.73,5.67 48.13,5.67 48.66,5.14 48.66,3.66 49.32,3 v4(53.38,3)
  GND2 w0.254: v9(71.32,40.67) 71.27,40.63 70.93,40.63 70.46,41.1 70.29,41.1 v8(70.02,41.37) v8(70.02,41.88)
  IN4 w0.254: v8(73.17,40.05) 73.17,39.85 70.83,37.51 70.83,34.21 70.6,33.99 v7(70.6,33.6)
  IN4 w0.508: v7(100.58,37.23) 100.32,37.48 100.32,44.99 v7(100.4,45.07) v7(100.4,45.7) 100.2,45.91 100.2,48.93 102.55,51.28 102.75,51.28 103.17,51.7 v4(103.17,52.56)
  BOTTOM w0.203: PR303.1 v4(182.49,15.48) 182.13,15.12 179.96,15.12 179.47,15.6 175,15.6 174.54,15.15 170.33,15.15 169.97,14.79 169.97,13.8 170.17,13.6 R10931.2 ; R478.2 50.79,3.74 51.06,3.47 R485.1 ; R253.1 252.47,27.22 252.88,27.63 252.88,31.19 v4(252.6,31.48) 252.6,32.01 253.18,32.6 ; PR150.2 v8(73.17,40.05) ; v4(103.17,52.56) 103.17,52.45 103.72,51.9 C58.2 ; v8(70.02,41.37) v8(70.02,41.88) 70.02,42.87 70.04,42.89 PR131.2
  BOTTOM w0.254: v8(178.96,14.41) 178.96,13.9 178.74,13.68 PU19.5 ; CN9.17 24.05,15.8 23.31,16.54 v4(22.73,16.54)
  BOTTOM w0.381: v4(250.92,32.6) CN7.2 253.18,32.6 C262.2 ; R276.2 41.04,24.9 v4(40.76,24.62) ; R329.2 40.82,20.33 41.08,20.59 41.08,20.6 41.37,20.89 41.37,21.2 41.5,21.33 v4(41.5,21.9) ; 95.37,33.83 95.68,33.83 98.55,30.97 99.31,30.97 99.88,30.4 107.74,30.4 110.2,32.85 R220.2 ; Q8.2 186.81,31.73 187.19,31.35 188.46,31.35 188.76,31.05 v4(191.51,31.05) ; 142.18,4.83 144.01,6.66 144.01,8.06 145.16,9.21 R481.2
  BOTTOM w0.508: R395.1 252.83,14.78 v4(252.83,15.26) ; v4(232.18,11.79) 231.79,11.41 Q34.2 ; R381.2 243.08,15.47 244.06,14.49 v4(244.06,13.92) ; v4(249.83,16.17) 249.97,16.17 250.24,15.9 R379.2 ; R284.2 v4(254.25,31.48) ; R485.1 52.1,3.18 53.21,3.18 v4(53.38,3)
  vias: v4(6.34,11.49) v4(6.98,11.51) v4(8.63,16.42) v4(9.26,16.42) v4(38.81,32.58) v4(38.86,52.64) v4(38.86,51.96) v4(39.16,31.99) v4(39.54,51.96) v4(39.49,32.58) v4(39.57,52.67) v4(83.31,36.36) v4(84.37,31.41) v4(85.01,31.41) v4(85.82,32.24) v4(92.02,31.88) v4(92.6,32.24) v4(93.03,32.72) v4(93.52,33.15) v4(94.05,33.64) v4(99.13,5.76) v4(99.77,5.76) v4(100.43,5.76) v4(101.06,5.76) v4(101.72,5.76) v4(133.55,2.45) v4(134.21,2.48) v4(134.87,2.48) v4(135.5,2.48) v4(136.19,2.48) v4(136.82,2.48) v4(191.51,31.71) v4(192.2,32.37) v4(192.2,31.74) v4(192.17,31.07) v4(192.17,30.41) v4(192.53,25.56) v4(192.83,25) v4(193.16,25.56) v4(193.47,25) v4(198.55,46.36) v4(198.57,47.68) v4(198.57,47) v7(100.6,36.72) v10(100.6,36.72)
+3V_EC_VCC: length 4.1
  BOTTOM w0.117: v4(52.72,3.81) 52.56,3.81 51.81,4.55 R485.2
  BOTTOM w0.381: R485.2 51.98,4.84 C455.1 52.98,4.97 52.98,5.96 v8(52.67,6.26)
  vias: v8(52.89,9.91)
+3V_LCDVCC:
  vias: v4(80.92,30.08)
+3V_PANEL: length 81.2
  IN1 w1.016: 16.15,11.26 14.68,11.26 13.54,12.4 13.54,19.31 15.11,20.89 33.34,20.89 40.71,28.25 40.71,30.26 43.12,32.67 51.94,32.67 52.36,33.09 56.29,33.09 57.4,31.99 59.28,31.99 ; 79.62,36.57 79.62,36.02 79.37,35.77 79.37,35.52 78.79,34.94 75.09,34.94 74.49,34.35 72.79,34.35 72.24,34.9 68.69,34.9 65.96,32.16 64.21,32.16
  vias: v4(17.04,11.71) v4(17.04,11.06) v4(17.7,11.21) v4(80.46,37.53) v4(80.59,38.17) v4(81.78,37.83) v4(83.43,32.62)
+3V_PANEL_CONN:
  vias: v4(19.02,11.21)
+3V_POA_R:
  vias: v4(170.55,9.25)
+3V_RTC: length 212.4
  TOP w0.305: v1(83.19,30.31) 82.18,31.33 v4(77.72,31.33) 76.3,31.33 D3.1 ; v3(96.34,27.85) 96.34,28.15 93.44,31.05 91.26,31.05 89.86,32.44 v1(89.86,32.87) 91.89,32.87 94.63,35.62 94.63,38.74 94.27,39.11 94.27,39.7 R95.1 94.96,40.16 C14.1 R89.1
  IN1 w0.305: v3(87.5,12.12) 86.68,11.31 74.49,11.31 v2(74.31,11.49) 74.01,11.79 66.31,11.79 60.83,6.31 54.81,6.31 53.44,7.68 48.94,7.68 42.92,13.69 41.98,13.69 41.7,13.98 v4(41.7,15.4) ; v1(89.86,32.87) 89.61,33.13 88.89,33.13 88.59,33.43 87.7,33.43 84.58,30.31 v1(83.19,30.31)
  GND1 w0.203: v2(113.24,38.69) v9(113.24,39.03)
  GND1 w0.305: v2(74.31,11.49) 74.34,11.46 v9(74.82,11.46)
  IN2 w0.305: v4(37.05,57.03) 40.58,53.5 40.58,51.26 38.63,49.31 38.63,35.13 40.92,32.85 40.92,26.52 42.07,25.37 42.74,25.37 v4(43.12,25.74) 43.33,25.53 43.33,20.51 42.24,19.42 42.24,17.89 41.7,17.36 v4(41.7,15.4) ; v3(87.5,12.12) 87.93,12.55 88.69,12.55 93.45,17.32 93.45,21.41 94.44,22.39 94.44,25.95 v3(96.34,27.85) 96.62,28.13 97.28,28.13 97.58,28.43 98.06,28.43 98.99,29.36 v9(98.99,30.32)
  IN3 w0.305: v8(46.81,26.14) 48.63,26.14 49.02,26.52 49.75,26.52 v7(50.16,26.93) ; v9(113.24,39.03) 112.68,39.03 111.55,37.9 110.56,37.9 110.15,37.5 110.15,37.3 109.28,36.43 108.86,36.43 108.2,35.78 107.59,35.78 107.36,36.01 106.4,36.01 106.23,35.84 106.14,35.84 105.18,34.88 104.51,34.88 103.65,34.03 103.65,31.21 102.9,30.46 99.61,30.46 99.47,30.32 v9(98.99,30.32)
  GND2 w0.305: v9(74.82,11.46) 74.85,11.49 v8(75.33,11.49)
  IN4 w0.305: v7(50.16,26.93) 52.42,29.19 v8(55.24,29.19)
  BOTTOM w0.305: R141.1 34.97,57.62 C44.2 35.55,57.03 v4(36.19,57.03) v4(37.05,57.03) ; v8(55.24,29.19) 59.18,29.19 60.32,28.05 D39.1 ; v4(43.12,25.74) 43.19,25.81 45.66,25.81 45.82,25.65 46.37,25.65 46.81,26.09 v8(46.81,26.14) 46.81,27.13 46.23,27.71 R251.1 ; v8(75.33,11.49) 75.82,11 BAT1.8
  vias: v7(113.05,39.52) v8(113.05,39.52)
+3V_S2:
  vias: v4(189.78,24.62)
+3V_SPI: length 2.7
  TOP w0.203: R9.1 43.3,42.35 43.5,42.15 44.14,42.15 v4(44.32,41.97) 44.7,42.35 v4(44.7,42.53) R13.1
  vias: v4(42.28,43.7)
+3V_TP_CLICK: length 55.2
  IN2 w0.305: v9(144.72,9.61) 145.2,10.09 152.51,10.09 153.54,11.12 v9(158.21,11.12)
  IN3 w0.305: v8(158.06,9.96) 158.54,10.45 158.54,10.79 v9(158.21,11.12) ; v8(130.68,9.53) v8(128.64,9.53)
  GND2 w0.305: v8(144.38,9.69) 144.64,9.69 v9(144.72,9.61) ; v8(158.57,11.12) v9(158.21,11.12)
  IN4 w0.305: v8(161.66,10.93) 161.59,11.01 160.67,11.01 v8(160.6,10.93)
  BOTTOM w0.279: Q48.5 162.95,10.93 ; Q48.2 159.28,10.93
  BOTTOM w0.305: 132.15,7.63 132.15,6.64 132.46,6.32 R450.2 133.62,5.62 v4(137.64,5.62) 138.37,5.62 139.07,6.32 142.37,6.32 143.1,7.05 CN12.1 143.1,8.26 143.3,8.47 143.3,9.7 143.1,9.9 C446.1 143.71,10.4 143.88,10.22 R481.1 v8(144.38,9.69) ; 132.15,7.63 127.48,7.63 126.9,8.21 R514.1 ; 132.15,7.63 132.15,8.73 132.42,9.01 R444.2 ; CN16.8 158.95,9.07 v8(158.06,9.96) ; 162.95,10.93 163.14,10.74 R676.2 163.84,10.74 164.62,11.52 v4(164.84,11.52) 166.68,11.52 Q6063.3 ; 159.28,10.93 159.09,11.12 v8(158.57,11.12)
+3V_TS:
  vias: v4(201.42,49.87)
+3V_WLAN:
  vias: v4(92.45,52.41)
+3VPCU_HW_SD: length 3.9
  TOP w0.381: PR24.1 PC46.1 156.64,44 v4(156.97,43.67) 157.46,43.18 PU4.5
+4.6V_PD_C1: length 11.5
  BOTTOM w0.254: PR521.2 196.56,28.81 196.51,28.86
  BOTTOM w0.508: 196.51,28.86 196.51,29.14 195.37,30.28 195.37,31.43 195,31.79 PU17.5 193.54,31.79 193.47,31.87 PR325.2 PC233.1 PC244.1 v4(191,32.99) 190.49,32.99 189.99,32.49 PQ27.3
+4.6V_PD_C2: length 9.5
  BOTTOM w0.203: 196.21,15.22 195.04,15.22 194.91,15.09 PR509.2
  BOTTOM w0.508: 193.16,10.65 193.16,11.26 193.96,12.06 PR507.2 PC241.1 195.71,12.06 196.14,12.49 PU21.5 v4(196.74,13.57) 196.74,14.69 196.21,15.22
+5V:
  vias: v4(192.07,17.76) v4(192.65,18.07) v4(224.78,12.68) v4(225.42,13.82) v4(225.47,12.68) v4(234.54,6) v4(234.51,5.27) v4(234.51,4.26)
+5V_PVDD: length 4.6
  BOTTOM w0.203: U19.41 243.72,7.87 v4(243.66,7.81) ; v4(243.26,11.5) 243.26,11.33 243.32,11.27 C415.1 243.32,10.66 244.11,9.87 U19.46
  BOTTOM w0.508: v4(243.26,11.5) C384.1
  vias: v4(233.34,7.92) v4(234.54,7.1) v4(240.23,7.66) v4(240.46,8.27) v4(240.91,7.6)
+5V_S2:
  vias: v4(189.78,19.74)
+5V_USBP0_L:
  vias: v4(199.13,23.98)
+5V_USBP1_L:
  vias: v4(200.78,8.74)
+5VA: length 19.7
  IN2 w0.305: v4(253.36,5.25) 252.01,5.25 248.97,2.2 243.5,2.2 242.11,3.59 240.9,3.59 v4(240.86,3.62)
  BOTTOM w0.203: U19.26 249.75,4.82 250.21,4.36 250.79,4.36 250.95,4.51
  BOTTOM w0.305: v4(253.36,5.25) C462.1 252.91,4.39 252.85,4.33 C461.1 252.04,4.33 251.86,4.51 v4(251.62,4.51) 250.95,4.51
+5VS5_PD: length 69.8
  TOP w0.508: v4(188.11,15.2) 188.72,15.81 188.72,18.9 190.75,20.94 190.75,22.46 191.26,22.97 192.4,22.97 192.65,23.22 194.56,23.22 194.81,23.48 194.81,24.37 194.94,24.49 v4(194.94,25.13) 194.99,25.18 194.99,27.08 196.72,28.81 199.64,28.81 200.78,27.67 v4(205.1,27.67) 211.35,27.67 212.56,26.46 218.88,26.46 219.88,27.46 221.69,27.46 224.66,24.49 228.09,24.49 228.97,25.38 v4(229.86,25.38)
  BOTTOM w0.356: PQ23.4 190.86,13.17 190.12,12.44 PR25.2
  BOTTOM w0.508: R10998.1 v4(229.86,25.38) ; v4(194.94,25.13) 194.68,25.38 194.3,25.38 193.43,26.26 PQ26.4 192.88,26.26 192.23,26.91 191.89,26.91 191.14,27.66 PR522.2 189.6,27.66 189.25,28.01 PD12.1 ; v4(188.11,15.2) 188.17,15.13 PD10.1 188.72,12.68 188.96,12.44 PR25.2
+V3.3S_SEN: length 134.3
  TOP w0.508: v4(161.13,17.61) 161.21,17.61 162.17,16.64 163.84,16.64 164.86,15.63 v4(166.31,15.63) 166.47,15.63 v4(168.65,13.44) 169.54,12.55 185,12.55 187.28,14.83 187.28,15.64 187.78,16.14 v4(187.78,18.65) 187.78,20.46 v4(188.56,21.25)
  IN2 w0.508: v4(157.3,5.93) 157.3,6.94 157.73,7.37 v4(157.73,8.15) ; v9(146.27,6.92) 146.27,6.33 147.26,5.34 v4(151.3,5.34)
  IN3 w0.508: v8(164.46,12.61) 164.26,12.61 163.95,12.91 163.95,14.74 164.84,15.63 v4(166.31,15.63)
  IN4 w0.508: v4(188.97,50.49) 189.99,50.49 v4(190.37,50.87) 191.35,50.87 193.49,48.72 v4(193.49,46.22) 191.41,44.14 191.41,34.78 190.14,33.51 190.14,24.67 188.02,22.55 188.02,21.8 v4(188.56,21.25)
  BOTTOM w0.203: R174.2 R169.2 193.08,50.11 193.36,50.38 194.25,50.38 194.33,50.3 Q11.2 ; R413.2 157.14,12.18 157.19,12.12 157.55,12.12 157.93,11.74 ; v4(188.97,50.49) 188.77,50.28 R177.2 ; v4(166.31,15.63) 165.98,15.29 R420.2 165.98,14.66 165.95,14.63 R421.2 ; v4(168.65,13.44) 168.57,13.36 R500.2 ; v4(161.13,17.61) 161.84,17.61 162.05,17.4 162.05,16.64 162.35,16.34 163.04,16.34 ; R461.1 147.38,10.31 148.57,10.31 149.6,9.28 149.6,5.82 v8(149.7,5.72) ; R411.1 163.04,16.34 ; 163.04,16.34 R412.1
  BOTTOM w0.254: Q11.2 Q11.5 194.33,46.74 194.05,46.46 193.67,46.46 193.49,46.28 v4(193.49,46.22) 193.67,46.04 194.95,46.04 195.93,47.02 R186.2 ; Q10.5 Q10.2 v4(190.37,50.87)
  BOTTOM w0.508: C383.1 C414.1 153.71,10.86 154.03,10.54 C378.1 ; C378.1 157.72,10.54 157.93,10.75 157.93,11.74 158.03,11.84 158.26,11.84 158.73,12.31 C379.1 158.78,12.48 C467.1 159.67,12.7 160.34,13.37 Q27.2 160.34,13.77 158.66,15.46 D21.1 158.66,16.76 158.87,16.97 R390.2 160.02,17.48 160.14,17.61 v4(161.13,17.61) ; C378.1 157.32,10.07 157.03,9.78 C377.1 157.03,8.84 v4(157.73,8.15)
  vias: v4(143.05,4.45) v4(143.68,4.45) v4(144.32,4.45) v4(152.32,5.34) v4(152.95,5.34) v7(146.02,7.91) v7(146.04,6.66) v7(146.32,4.99) v7(146.32,4.71) v7(146.66,6.76) v8(146.02,7.91) v8(146.04,6.66) v8(146.32,4.99) v8(146.32,4.71) v8(146.66,6.76) v10(146.32,4.99) v10(146.32,4.71)
+VCC_PRIM_SRC:
  vias: v4(160.12,32.09) v5(159.4,31.95)
+VCC_VCCIO_SRC:
  vias: v4(51.56,36.61) v5(51.58,37.42)
+VCCAPLL_1P0: length 9.3
  IN3 w0.305: v8(106.67,46.9) v8(106.67,46.46) 107.21,45.93 109.62,45.93 109.87,45.68 109.87,44.53 110.15,44.25 110.33,44.25 110.76,43.82 111.6,43.82 111.83,43.59 112.92,43.59 v9(113.07,43.44)
  GND2 w0.305: v9(113.07,43.44) 113.07,43.34 113.23,43.19 v8(113.23,42.98)
  vias: v1(112.74,43.75) v1(113.23,43.82) v2(112.74,43.75) v2(113.23,43.82) v4(104.39,47.99) v4(105.84,47.73)
+VCCDSW_1P0: length 1.9
  GND2 w0.203: v8(107.48,40.11) 107.62,40.11 v9(108.08,40.56) 108.07,40.57 v8(108.07,41.02) 107.66,41.02 107.64,41 v8(107.46,41)
  vias: v1(108.29,40.24) v1(108.56,40.56) v2(108.29,40.24) v2(108.56,40.56)
+VCCIO_S2:
  vias: v4(76.03,29.62) v4(78.02,30.03)
+VCCPAZIO: length 1.5
  TOP w0.229: 114.23,38.45 U3.AT23
  GND1 w0.203: v9(114.27,38.01) 114.27,38.06 v2(114.06,38.28)
  GND2 w0.254: v9(114.27,38.01) 114.19,38.09 v8(113.41,38.09)
  vias: v4(112.11,34.02) v4(112.57,36.08)
+VCCPDSW_3P3: length 19.9
  TOP w0.305: R115.1 99.64,36.84 v4(99.56,36.91) 99.56,37.52 99.29,37.79 99.29,38.58 99.03,38.84 R104.1
  GND1 w0.305: v2(111.75,40.37) 111.4,40.37 v2(111.27,40.23) 111.03,40.48 v9(110.74,40.48) ; v9(99.49,35.67) 99.63,35.81 v2(99.63,36.12)
  IN3 w0.305: v9(110.74,40.48) 110.29,40.48 109.73,39.92 109.73,39.62 108.16,38.05 107.6,38.05 106.92,38.73 105.36,38.73 102.57,35.94 99.76,35.94 v9(99.49,35.67)
  GND2 w0.305: v8(110.97,40) 110.97,40.24 v9(110.74,40.48)
+VCCPSPI: length 95.7
  GND1 w0.203: v9(111.56,38.64) 111.72,38.47 v2(111.72,38.28)
  IN2 w0.508: v4(49.12,25.69) 48.86,25.69 46.37,28.18 46.37,29.5 44.9,30.97 44.9,33.99 41.47,37.42 41.47,41.47 43.17,43.17 43.17,45.4 43.89,46.11 v4(43.89,46.97)
  IN3 w0.381: v9(111.56,38.64) 109.73,38.64 107.92,36.83 107.55,36.83 107.28,37.1 106.17,37.1 104.88,35.82 104.33,35.82 103.55,35.04 100.29,35.04 95.65,30.39 93.72,30.39 93.28,29.95 89.99,29.95 88.24,28.2 81.23,28.2 80.39,29.04 71.94,29.04 71.38,28.47 68.16,28.47 67.97,28.66 63.9,28.66 63.49,29.06 59.4,29.06 57.47,27.13 52.04,27.13 50.59,25.69 v4(49.12,25.69)
  GND2 w0.254: v8(111.4,38.22) 111.42,38.24 111.42,38.5 v9(111.56,38.64)
  vias: v4(46.98,46.54)
+VCCSFR: length 21.9
  GND2 w0.254: v7(115.95,46.26) 115.44,46.26 115.34,46.36 v9(115.31,46.36)
  IN4 w1.016: 98.14,54.67 99.16,55.68 104.36,55.68 104.51,55.84 110.71,55.84 112.16,54.39 113.84,54.39 114.73,53.49 114.73,51.74 115.56,50.91 115.56,50.65
  vias: v1(115.72,45.96) v1(115.72,45.57) v2(115.72,45.96) v2(115.72,45.57) v4(93.44,43.52) v4(93.54,42.33) v4(94.18,42.33) v4(95.55,42.88) v4(96.44,46.82) v4(97.53,50.35) v8(97.43,53.45) v8(97.43,53.02) v8(97.43,52.59) v8(97.83,53.45) v8(97.83,53.02) v8(97.83,52.59) v8(98.24,53.45) v8(98.24,53.02) v8(98.24,52.59) v8(115.39,47.4) v8(115.39,47.12) v8(115.69,47.43) v8(115.69,47.15) v8(116.03,47.14)
