# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCST_CPU: length 140.6
  TOP w0.203: 102.03,58.49 101.23,59.28 R2.2
  TOP w0.508: 102.03,58.49 Q1.3 104.49,57.36 v4(103.65,56.52)
  IN2 w0.508: v4(103.65,56.52) 103.65,53.91 v4(101.85,52.1) 101.75,52 v4(101.09,52)
  IN3 w0.381: v8(125.8,51.98) 125.42,52.36 125.42,55.38 v8(125.43,55.39) 126.91,56.86 155.51,56.86 156.92,55.46 159.28,55.46 165.84,48.9 185.56,48.9 185.67,48.79 186.47,48.79 187.12,48.15 188.59,48.15 191.21,45.53 191.21,36.61 190.34,35.75 v4(190.34,34.68) ; v7(111.4,54.01) 111.4,54.95 110.64,55.71 110.64,56.57 111.17,57.11 118.16,57.11 v8(119.88,55.39)
  GND2 w0.203: v8(115.03,45.45) 114.9,45.32 v9(114.9,45.07) 115.18,45.07 v8(115.28,45.17)
  IN4 w0.381: v4(190.34,34.68) 189.96,34.68 188.16,32.88 188.16,29.51 186.8,28.15 185.39,28.15 184.6,27.36 184.6,21.75 v4(186,20.35)
  BOTTOM w0.203: R156.1 125.94,52.47 125.8,52.34 v8(125.8,51.98) 125.8,51.98 R167.1 R166.2 v4(125.04,52.31) 124.91,52.43 R163.1
  BOTTOM w0.381: v8(125.43,55.39) v8(119.88,55.39)
  vias: v1(115.22,44.84) v1(115.23,44.46) v2(115.22,44.84) v2(115.23,44.46) v4(89.71,42.78) v4(90.34,42.78) v4(93.54,40.8) v4(102.99,49.33) v4(114.17,46.34) v8(115.21,45.75)
+VCCST_S2:
  vias: v4(92.78,47.38)
+VCCSTG: length 77.1
  GND1 w0.254: v2(115.17,43.33) 115.22,43.39 v2(115.22,43.72) 115.22,43.78 v9(114.88,44.12)
  IN2 w0.203: v9(115.06,46.77) 115.06,46.72 114.78,46.44 114.78,45.96 v9(114.62,45.8)
  IN2 w0.381: v9(114.62,45.8) 114.62,45.72 114.39,45.49 114.39,44.61 v9(114.88,44.12)
  IN3 w0.203: v8(108.99,52.28) 108.99,51.01 109.47,50.53 110.48,50.53 111.75,49.26 111.75,48.75 113.53,46.97 113.53,46.67 113.86,46.34 114.28,46.34 114.62,45.99 v9(114.62,45.8) ; v8(119.22,52.21) 119.22,52.07 117.64,50.49 116.74,50.49 116.12,49.86 116.12,48.15 115.06,47.08 v9(115.06,46.77)
  IN3 w0.508: v4(75.58,33.23) 75.48,33.33 75.48,33.81 v4(75.56,33.89) 75.96,34.29 75.96,36.4 78.3,38.74 81.77,38.74 84,40.97 84,42.24 85.2,43.44 90.6,43.44 91.01,43.02 93.86,43.02 95.62,44.79 95.62,50.25 95.78,50.4 95.78,52.31 97.26,53.79 104.37,53.79 106.09,55.51 107.97,55.51 109.06,54.41 109.06,53.27
  GND2 w0.203: v8(115.26,44.14) 115.25,44.12 v9(114.88,44.12) 114.53,44.12 v8(114.52,44.13) ; v9(114.62,45.8) 114.62,46.06 114.62,46.06 v8(114.62,46.21)
  BOTTOM w0.203: v8(114.62,46.21) 114.67,46.26 115.24,46.26 C88.2 ; R161.1 119.5,52.94 119.22,52.66 v8(119.22,52.21)
  vias: v1(115.22,45.95) v1(115.23,45.57) v2(115.22,45.95) v2(115.23,45.57) v7(108.81,52.61) v7(109.16,52.61) v7(109.34,52.28) v8(108.81,52.61) v8(109.16,52.61) v8(109.34,52.28) v10(108.81,52.61) v10(109.16,52.61) v10(109.34,52.28)
+VDDD_SUPPLY: length 15.8
  IN1 w0.508: v4(216.4,18.4) 216.4,18.78 218.31,20.68 218.56,20.68 219.2,21.32 226.38,21.32 v4(227.07,22)
  BOTTOM w0.508: v4(228.97,20.56) 229.24,20.82 R10994.1 ; v4(229.23,14.97) R10979.1 R10978.1 ; R10990.2 v4(216.4,18.4)
  vias: v4(227.07,25.51) v8(222.88,26.41) v8(223.89,26.41) v8(224.91,26.41)
+VIN: length 72.2
  TOP w0.203: v2(66.78,45.03) 67.02,44.78 PU5.M8
  GND1 w0.203: v2(66.52,45.73) 66.31,45.73 v9(66.19,45.61) v2(66.78,45.03)
  GND1 w0.254: v9(70.74,46.45) 70.66,46.45 v2(70.44,46.23)
  IN2 w0.254: v3(59.43,43.42) 59.56,43.29 61.89,43.29 62.21,43.6 63.43,43.6 64.16,44.33 64.16,45.79 64.43,46.07 64.74,46.07 64.96,45.84 65.63,45.84 65.86,45.61 v9(66.19,45.61)
  IN2 w0.508: v4(165.6,6.97) 165.6,7.47 166.62,8.49 170.43,8.49 170.68,8.74 173.04,8.74 177.9,3.89 188.59,3.89 188.87,4.17 193.8,4.17 193.92,4.3 197.2,4.3 197.61,3.89 202.28,3.89 207.38,9 214.62,9 216.06,10.43 v4(216.15,10.43)
  GND2 w0.203: v8(70.28,46.32) 70.61,46.32 v9(70.74,46.45)
  BOTTOM w0.254: v8(70.28,46.32) 70.21,46.39 PR108.2
  BOTTOM w0.508: PC81.2 70.39,56.67 69.88,56.17 v5(68.8,56.17) ; R380.1 v4(216.15,10.43)
  vias: v4(35.88,19.01) v4(36.51,19.03) v4(37.2,19.03) v4(47.64,21.39) v4(47.65,20.74) v4(48.28,21.44) v4(48.28,20.74) v4(75.03,36.23) v4(164.43,20.53) v5(57.65,44.38) v5(58.49,44.33) v5(63.01,34.15) v5(63.01,33.42) v5(63.75,34.15) v5(63.75,33.42) v5(64.29,51.85) v5(64.29,51.11) v5(65.02,51.85) v5(65.02,51.11) v5(68.07,56.9) v5(68.07,56.17) v5(68.07,55.43) v5(68.83,56.9) v5(68.8,55.43) v5(73.58,37.02) v5(73.58,36.29) v5(74.21,19.62) v5(74.21,18.89) v5(74.32,37.02) v5(74.32,36.29) v5(74.95,19.62) v5(74.95,18.89) v5(75.69,19.62) v5(75.69,18.89) v5(83.99,23.23) v5(83.99,22.49) v5(83.99,21.76) v5(84.73,23.23) v5(84.73,22.49) v5(84.73,21.76) v5(160.98,46.01) v5(161.72,46.01) v5(164.36,21.43) v5(177.01,33.19) v5(177.01,32.45) v5(177.74,33.19) v5(177.74,32.45) v5(178.48,33.19) v5(178.48,32.45) v5(179.22,33.19) v5(179.22,32.45)
+VIN_PANEL:
  vias: v4(35.15,16.47) v4(35.58,14.26)
+VIN_VCC_CORE: length 21
  IN4 w0.254: v4(168.96,27.96) 168.96,27.29 169.49,26.76 172.38,26.76 172.64,26.51 180.77,26.51 181.91,27.65 181.91,29.28 183.92,31.28 183.92,32.12 v5(184.45,32.65)
  BOTTOM w0.203: v4(168.96,27.96) PR194.2
  vias: v4(183.2,35.01) v4(183.66,33.13) v4(185.31,33.54) v5(184.45,34.86) v5(184.45,34.13) v5(184.45,33.39)
+VIN_VCCGT:
  vias: v4(170.12,33.99) v4(172.49,32.72) v4(172.56,34.98) v5(171.39,34.84) v5(171.39,34.1) v5(171.39,33.37) v5(171.39,32.63)
+VIN_VCCSA:
  vias: v4(159.1,47.71)
AVCC_3.3VA: length 20.9
  IN2 w0.381: v4(153.05,6.13) 154.07,5.11 154.07,5.06 v4(154.63,4.5)
  IN3 w0.381: v8(163.65,8.82) 163.65,11.62 163.18,12.09
  BOTTOM w0.254: U20.D5 152.89,6.29 v4(153.05,6.13)
  BOTTOM w0.381: v4(154.63,4.5) 156.54,2.59 C453.1 159.32,2.59 163.65,6.92 v8(163.65,8.82)
  BOTTOM w0.508: L14.1 162.69,12.61 C454.1
  vias: v7(162.58,12.68) v7(162.78,12.48) v8(162.58,12.68) v8(162.78,12.48) v10(162.58,12.68) v10(162.78,12.48)
DVDD_IO: length 6
  BOTTOM w0.203: U19.9 248.95,12.72 249.27,13.04 C374.1
  BOTTOM w0.305: C374.1 249.27,13.77 249.36,13.86 C365.1 249.36,14.87 249.46,14.97 R379.1 249.2,15.51 248.8,15.11 v4(248.64,15.11) 248.49,15.26 R374.1
GND: length 685.5
  TOP w0.06: U3.V40 119.68,44.82 ; v12(119.21,35.81) 119.42,35.81 119.42,35.81 119.6,35.81 119.6,35.81 v12(119.85,35.81) ; U3.AN16 112.26,39.81
  TOP w0.076: v12(125.65,39.92) 125.65,40.14 125.65,40.15 125.65,40.33 125.65,40.33 v12(125.65,40.56)
  TOP w0.102: U3.BM20 U3.BM18 ; U3.K29 v2(116.96,47.15) U3.K33 v2(118.24,47.15) v2(118.89,47.15) v2(119.53,47.15) U3.K41 U3.K43 U3.K45 U3.K47 U3.K49 U3.K51 ; U3.E54 v2(123.72,48.38) U3.E50 ; U3.BG17 U3.BG15 U3.BG12 ; U3.BM16 v2(111.51,34.83) U3.BM14 ; U3.E34 v2(118.57,48.38) v2(119.21,48.38) v2(119.85,48.38) U3.E42 U3.E44 121.35,48.38 121.35,48.38 121.55,48.38 121.55,48.38 U3.E46 v2(122.42,48.38) ; v12(119.21,35.81) v12(118.57,35.81) v12(117.92,35.81) ; v12(117.6,35.07) 118.24,35.07 U3.BL35 ; v12(119.85,35.81) v12(120.5,35.81) ; U3.BB24 U3.BB22 ; U3.E26 v2(115.99,48.38) ; v12(118.24,36.55) v12(117.6,36.55) v12(116.96,36.55) v12(116.31,36.55)
  TOP w0.117: v2(261.28,30.46) 262.02,30.46 262.27,30.72 262.27,32.29 261.79,32.77 261.18,32.77 v3(260.64,32.23) ; SPAD2.1 205.5,58.89 205.48,58.91
  TOP w0.127: U3.BG2 U3.BG4 U3.BG6 U3.BG8 ; 113.39,36.28 U3.BF20 U3.BD20 U3.BB20 v2(113.41,37.32)
  TOP w0.152: U3.BH20 113.38,35.85 113.38,36.27 113.39,36.28 ; 99.21,50.12 99.05,49.97 v2(97.76,49.97) 96.65,49.97 96.45,49.76 96.45,48.46 v1(97.05,47.86) v1(97.46,47.45) 97.46,46.71 97.81,46.36 v1(98.6,46.36) v1(99.61,46.36) 103.36,46.36 103.56,46.57 105.45,46.57 v1(105.51,46.62) ; 99.21,50.12 v1(99.23,50.12) ; 99.21,50.12 99.36,49.97 v1(100.86,49.97) 101.04,49.79 ; v1(101.77,49.74) 101.72,49.79 101.34,49.79 ; v1(101.77,49.74) 101.75,49.74 101.72,49.72 ; v1(101.77,49.74) 101.72,49.69 101.72,49.11 v1(102.01,48.81) 102.47,48.81 v1(102.83,48.46) 103.07,48.22 104.59,48.22 v1(104.79,48.42) 105.07,48.42 v1(105.56,47.94) 105.86,47.63 v2(106.34,47.63) ; U3.BL8 v12(109.58,34.74) ; 114.7,37.29 U3.BB24
  TOP w0.178: v4(82.67,56.65) 82.67,57.06 82.67,57.06 PU1.11 ; 116.63,37.29 U3.AY30 ; 117.92,37.29 U3.AY34 ; U3.AY48 122.43,37.78 122.43,37.29 ; U3.AY42 120.5,37.78 120.5,37.29 ; 124.36,34.31 124.04,33.99 U3.BP52 ; U3.BC29 v12(116.31,36.55) U3.BG29 v12(116.31,35.57) v12(116.31,35.07) U3.BN29 ; 121.14,37.29 121.14,37.78 U3.AY44 ; U3.BB32 U3.AY32 ; 118.57,37.29 U3.AY36 ; PU3.11 v4(91.61,49.42) ; 123.07,37.29 123.07,37.78 U3.AY50 ; U3.AW25 U3.AY26 115.34,37.29 ; U3.AY24 114.7,37.29 ; U3.AY46 121.79,37.78 121.79,37.29 ; PU6.11 PU6.15 ; 115.99,37.29 U3.AY28
  TOP w0.203: PC36.2 PC35.2 PC29.2 94.91,50.66 95.17,50.92 v4(95.17,51.22) ; v4(101.16,58.76) 101.29,58.76 101.52,58.53 101.52,57.84 101.26,57.59 R7.1 ; U3.BA1 U3.BA3 U3.BA5 U3.BA7 U3.BA9 v2(110.31,37.66) ; PR56.1 168.8,34.63 v4(169.09,34.33) ; v2(103.6,42.5) 103.6,42.6 103.42,42.78 103.42,43.26 103.22,43.47 R59.2 ; U3.R4 108.69,45.71 U3.R2 108.54,45.73 106.85,45.73 v1(106.32,46.26) ; v2(82.21,59.73) v2(82.93,59.73) v2(83.66,59.73) v2(84.37,59.73) ; R93.2 v2(103.14,38.93) ; PC20.2 v5(85.67,51.7) ; PR26.2 v4(51.2,44.53) PR30.2 ; v2(72.84,43.8) 72.74,43.7 v2(72.57,43.7) 72.37,43.5 v2(72.28,43.5) ; v4(90.57,44.72) 90.67,44.82 91.46,44.82 91.79,45.15 PC49.2 ; v12(127.29,40.24) 127.29,40.24 U3.AM64 ; R65.2 102.86,42.4 103.08,42.18 v2(103.22,42.18) 103.26,42.13 R70.2 103.26,41.03 R82.2 ; PR53.1 188.45,36.46 v4(187.7,36.46) ; R126.1 104.41,33.64 104,34.05 R125.1 ; PC61.2 89.66,41.84 89.5,42 PC60.2 PC59.2 PC58.2 87.42,41.01 86.65,40.24 v4(85.97,40.24) PC62.1 ; C12.2 101.31,45.3 v2(101.49,45.47) ; v2(103.98,37.73) 104.11,37.6 104.77,37.6 104.84,37.67 R105.1 ; 84.09,39.22 84.42,38.89 R101.2 ; PC53.2 61.41,45.71 v5(61.4,45.73) ; PC24.2 v4(90.11,51.7) 89.63,51.22 PC28.2 ; PC41.2 91.3,47.75 91.59,48.04 v4(91.59,48.52) ; v4(40.91,43.06) 40.91,42.78 41.16,42.53 C1.2 R6.2 ; R36.1 102,51.59 102.26,51.86 v4(102.51,51.86) 102.74,51.63 R37.1 ; 124.17,40.49 124.42,40.24 ; v2(124.42,46.04) 124.67,45.79 U3.R55 ; EC1.1 v4(70.15,58.08) ; v12(127.36,39.71) 127.02,39.71 U3.AP64 ; EC3.1 v4(71.54,58.08) ; U3.G14 v2(111.48,47.39) ; PU7.11 56.72,42.32 v4(56.87,42.17) 57.14,42.17 57.19,42.12 PC55.2 ; U3.BH20 U3.BK20 U3.BM20 ; U3.R10 v2(110.04,45.71) ; v4(95.91,40.86) 96.24,41.19 C13.1 ; EC2.1 v4(70.83,58.1) ; PR47.1 v4(50.34,40.75) ; PC26.2 v4(68.9,52.19) ; 124.17,40.64 v2(124.42,40.88) ; U3.BA64 v12(127.32,37.66) ; v4(86.48,44.47) 86.79,44.77 PC50.2 ; U5.5 85.39,35.79 85.24,35.94 85.24,36.28 85.33,36.37 v4(85.62,36.37) ; v2(104.77,42.51) R62.2 ; U3.AY40 U3.BB40 ; 97.05,49.97 97.05,50.61 v2(97.05,50.62) ; U3.J5 v2(109.79,47.32) ; PC51.2 v4(50.59,43.03) ; U3.T58 v2(124.91,45.39) ; PC63.1 v2(73.4,38.91)
  TOP w0.254: U5.10 v4(81.96,35.29) ; U5.15 84.4,32.6 v4(84.63,32.37) 84.9,32.65 U5.16 ; v11(114.06,46.41) 113.99,46.34 113.48,46.34 U3.N20 ; v4(202.94,45.85) 202.94,47.15 202.74,47.35 CN1.18 ; PC79.1 163.81,33.21 v4(163.57,33.21) ; U3.A14 111.48,49.73 v2(111.49,49.75) ; v12(114.06,33.65) U3.BP22 ; U3.D10 110.42,48.53 U3.D8 v2(109.58,48.53) ; U5.13 82.35,33.79 v4(81.98,34.15) 82.12,34.29 U5.12 ; PU5.K6 v2(68.02,45.23) ; v2(111.16,36.55) U3.BG12 ; v2(130.65,35.36) v2(130.65,35.77) v2(130.65,36.18) R122.1 ; U3.A5 v2(108.66,49.39)
  TOP w0.279: v5(85.67,51.7) 86.31,51.7 86.89,52.28 PU8.3
  TOP w0.305: v4(266.82,30.11) 266.82,30.41 267.16,30.75 CN3.A1 ; v4(266.69,36.43) 266.88,36.25 CN3.A12 ; CN18.A1 267.18,16.75 v2(267.05,16.62) ; v5(76.04,51.68) 76.3,51.43 PR19.1 ; CN18.A12 267.39,22.25 v2(267.05,22.59)
  TOP w0.381: v4(41.29,55.35) 41.29,55.28 41.92,54.64 MR1.3 ; PC54.1 62.13,43.08 v4(62.76,43.08) ; C10.2 102.91,47.82 C11.2 v4(102.28,46.97) ; C23.1 42.1,35.85 v4(42.34,35.62) ; v4(160.34,44.13) PU4.2 162.11,44.13 162.3,44.31 PR31.1 ; C24.2 96.19,34.44 95.47,35.16 v4(95.47,35.75) ; PC43.2 77.69,47.72 v4(77.79,47.82) ; v4(59.43,45.07) PC57.1 ; C31.2 v2(88.09,32.16) ; PC46.2 v4(157.29,45.56) 157.77,45.08 PU4.4 ; v4(51.02,48.19) U1.4
  TOP w0.508: PC62.1 84.09,40.24 v4(83.81,39.97) 83.81,39.5 84.09,39.22 ; R140.2 R139.2 v4(259.04,13) 258.78,13 v4(257.93,13.85) ; C29.2 C28.2 198.67,32.26 v2(198.29,31.88) ; R81.2 v4(43.2,40.81) ; HOLE11.1 267.6,1.87 267.46,2.01 ; C7.2 42.54,55.11 42.29,55.35 v4(42.03,55.35) ; v4(43.43,34.15) 43.38,34.1 42.24,34.1 C26.1 C30.1 ; v4(44.44,57.64) 44.44,56.84 D2.1 ; v4(90.57,44.72) 91.14,44.15 PC56.2 ; PC25.1 95.2,51.19 v4(95.17,51.22) ; PC45.2 94.11,46.15 94.52,45.75 v4(94.71,45.75) ; C23.1 C21.1 ; C25.1 42.62,34.97 v4(42.79,34.79) ; C15.2 97.78,38.23 v4(98.1,37.92) CL1_CL1.1 ; v4(95.91,40.86) 95.75,40.71 C14.2 ; PC65.1 70.45,37.61 v4(70.2,37.35) ; 257.15,0.98 SPAD12.1 ; PC64.1 66.52,37.68 v4(66.49,37.66) ; C22.2 v4(80.46,36.46) ; PC6.1 89.41,59.08 v4(89.81,58.68)
  IN1 w0.061: v12(117.6,35.07) 117.51,35.17 117.51,35.38 117.28,35.6 v12(117.28,35.81)
  IN1 w0.127: v12(122.43,35.81) v12(123.07,35.81) v12(123.72,35.81) v12(124.36,35.81) v11(125.01,35.81) v12(125.01,36.3) 125.01,36.36 124.98,36.39 124.98,36.7 125.01,36.73 v12(125.01,36.8) ; v12(122.43,35.81) v12(121.79,35.81) ; v12(122.43,35.81) 122.18,35.57 v11(122.11,35.57) ; v11(122.11,35.57) v12(122.11,35.07) ; v11(122.11,35.57) 122.03,35.57 v12(121.79,35.81) ; v12(114.06,35.81) v12(114.7,35.81) v12(115.34,35.81) v12(115.99,35.81) 116.24,35.57 v12(116.31,35.57) v12(116.31,35.07) ; v12(117.28,35.81) v12(117.92,35.81) v12(118.57,35.81) v12(119.21,35.81) v12(119.21,36.3) ; v12(125.65,41.85) v12(125.65,41.21) v12(125.65,40.56) v12(125.65,39.92) v12(125.65,39.27) v12(125.65,38.63) ; v12(121.79,35.81) v12(121.14,35.81) ; v12(117.6,36.55) v12(116.96,36.55) v12(116.31,36.55)
  IN1 w0.152: v1(112.36,37.04) 112.31,37.04 112.07,37.28 112.07,37.49 112.12,37.54 v2(112.12,37.78) ; v12(126.15,38.63) v12(125.65,38.63)
  GND1 w0.076: CN2.27 37.83,39.4 ; CN2.39 37.84,42.4 ; CN2.51 37.76,45.4
  GND1 w0.102: v12(116.31,36.55) v12(116.96,36.55) v12(117.6,36.55) v12(118.24,36.55)
  GND1 w0.127: v2(121.16,44.84) 121.14,44.86 120.69,44.86 v2(120.67,44.84) ; v2(123.18,41.5) 123.18,41.45 v9(122.92,41.2) ; v2(118.69,45.4) 118.69,45.31 v9(118.49,45.11) 118.69,44.91 v2(118.69,44.79) ; v2(123.71,43.72) 123.61,43.72 v9(123.43,43.9) ; v2(122.16,45.96) 122.15,45.96 v9(121.89,45.7) 121.66,45.93 v2(121.66,45.95) ; v2(121.66,42.6) 121.66,42.58 v9(121.91,42.33) 122.15,42.58 v2(122.15,42.6) ; v2(123.42,47.17) 123.42,47.39 v9(123.28,47.53) ; v2(123.15,42.6) 123.15,42.58 v9(122.9,42.33) 122.65,42.58 v2(122.65,42.6) ; v2(124.66,43.78) 124.66,43.8 v9(124.89,44.03) 125.12,43.79 v2(125.16,43.79) ; v2(117.72,43.7) v2(117.72,44.3) v2(117.72,44.84) 117.75,44.86 117.75,45.35 v2(117.7,45.4) ; v9(124.12,42.5) 124.02,42.6 v2(123.64,42.6) ; v9(118.5,43.44) 118.69,43.25 v2(118.69,43.16) ; v9(107.74,47.51) 107.93,47.32 v2(108.81,47.32) ; 116.94,40.14 v2(116.71,40.37) 116.93,40.59 116.93,41.13 ; v2(122.64,45.95) 122.64,45.94 v9(122.89,45.7) 123.14,45.94 v2(123.14,45.95) ; v2(125.65,47) 125.57,47.08 v2(125.29,47.08) U3.L57 v9(124.99,47.35) 124.69,47.06 v2(124.68,47.06) ; v2(108.29,48.48) 108.29,48.78 v9(108.45,48.93) ; v9(107.94,44.18) 107.97,44.15 v2(108.29,44.15) ; v2(118.69,44.3) 118.69,44.18 v9(118.5,43.99) ; v2(123.64,41.49) 124.05,41.49 v9(124.09,41.53)
  GND1 w0.152: v9(123.64,37.88) 123.72,37.96 v2(123.72,38.27) ; v9(114.98,38.32) 115.03,38.28 v2(115.03,37.98)
  GND1 w0.203: v2(112.77,46.41) 112.68,46.41 v9(112.46,46.19) 112.25,46.41 v2(112.12,46.41) ; v9(109.75,37.64) 109.77,37.66 v2(110.31,37.66) v2(110.78,37.66) ; v12(127.29,40.24) 126.64,40.24 v9(126.61,40.27) ; v2(126.39,47.32) 126.25,47.47 v9(125.99,47.47) 125.99,47.16 v2(126.15,47) ; v9(124.53,45.67) 124.42,45.79 v2(124.42,46.04) ; v2(110.29,40.88) v9(109.94,40.88) ; v9(126.33,45.02) 126.33,45.33 v2(126.39,45.39) ; v2(125.9,45.39) 125.65,45.14 v9(125.19,45.14) 124.94,45.39 v2(124.91,45.39) ; v2(103.22,42.18) 103.22,41.95 v9(103.4,41.77) ; v9(126.82,45.07) 126.82,45.3 v2(126.91,45.39) ; v12(109.58,34.74) 109.24,34.74 v9(108.76,35.22) 108.29,35.22 v2(108.29,35.22) v2(108.29,34.31) ; v12(123.99,33.28) v12(123.99,33.03) ; v2(124.42,40.24) 124.42,40.32 v9(124.18,40.56) 124.18,40.64 v2(124.42,40.88) ; v9(112.57,37.83) 112.7,37.96 112.89,37.96 112.96,38.03 v2(113.08,38.03) ; v2(71.02,46.73) 71.02,46.81 71.75,47.54 v9(71.75,47.64) ; v2(111.48,48.38) 111.29,48.38 v9(111.06,48.61) ; v2(104.77,42.51) 104.77,42.13 v9(104.7,42.05) v2(104.7,41.67) ; v2(73.4,38.91) 73.4,38.44 v9(73.3,38.34) ; v9(109.97,48.78) 109.72,48.53 v2(109.58,48.53) ; v2(71.34,51.65) v9(71.34,52.09) ; v2(124.42,41.53) 124.09,41.53 v9(124.09,41.53)
  GND1 w0.254: v2(70.02,48.23) v2(69.52,48.23) 69.03,48.23 v9(68.92,48.33) ; v9(113,45.17) 112.77,45.4 v2(112.74,45.4) ; v2(110.79,34.83) v2(111.51,34.83) 111.51,35.4 v9(111.55,35.44) ; v2(116.96,47.15) 116.96,47.23 v9(117.15,47.43) ; v2(113.41,48.38) 113.41,48.72 v9(113.35,48.78) ; v9(124.26,47.6) 124.04,47.38 v2(124.04,47.15) ; v2(118.24,47.15) 118.32,47.15 v9(118.56,47.38) 118.79,47.15 v2(118.89,47.15) ; v9(67.18,42.26) 67.2,42.23 v2(67.52,42.23) ; v2(113.73,47.15) 113.73,47.22 v9(114.23,47.71) 114.38,47.56 v2(114.38,47.15) ; v2(111.75,43.16) v9(112.21,43.16) ; v2(113.73,42.04) v2(113.73,43.16) ; v2(70.52,47.73) 70.61,47.82 v9(70.61,48.53) ; v2(110.1,36.05) 109.46,36.05 v9(109.25,35.84) ; v2(71.52,48.23) v9(71.93,48.23) ; v9(110.58,47.05) 110.31,47.32 v2(110.29,47.32) ; v9(100.86,37.95) 101.19,38.28 v2(101.65,38.28) ; v2(124.42,42.17) 124.42,42.2 v9(124.12,42.5) ; v9(68.42,47.87) 68.06,48.23 v2(68.02,48.23) ; v2(111.48,47.39) 111.41,47.39 v9(111.17,47.15) 111.42,46.9 v2(111.48,46.9) ; v9(125.37,48.52) 125.11,48.26 v2(125.11,48.25)
  IN2 w0.094: v3(260.64,32.23) 260.1,32.23 259.07,31.2 v4(259.07,31) ; v3(267.05,21.55) v3(267.05,21.95)
  GND2 w0.076: 37.84,39.4 37.83,39.4 CN2.27 ; 37.87,42.37 37.84,42.4 CN2.39 ; 37.79,45.42 37.76,45.4 CN2.51
  GND2 w0.127: v8(107.05,36) 107.05,35.85 v9(106.78,35.58) ; 123.16,37.93 122.96,37.73 122.79,37.73 v8(122.75,37.69) 122.72,37.73 122.14,37.73 v8(122.11,37.69) 122.08,37.73 121.5,37.73 v8(121.46,37.69) 121.42,37.73 120.86,37.73 v8(120.82,37.69) 120.78,37.73 120.2,37.73 v8(120.16,37.69) 120.12,37.73 119.54,37.73 v8(119.5,37.69) 119.46,37.73 119.22,37.73 119.2,37.75 ; v9(119.48,40.09) 119.66,39.91 v8(119.66,39.79) ; v8(71.24,50.92) v9(70.84,50.92)
  GND2 w0.152: v8(107.8,34.85) 108.17,35.22 v9(108.76,35.22)
  GND2 w0.203: v8(107,42.21) 107,42.36 v9(106.83,42.53) ; v9(111.37,40.88) 111.37,40.29 v8(111.42,40.23) ; v9(111.37,40.88) 111.63,40.62 v8(112.22,40.62) ; v9(111.37,40.88) 111.3,40.82 v8(110.96,40.82) ; v9(49.98,11.8) 50.09,11.91 v8(50.39,11.91) ; v8(122.97,36.94) 122.72,36.69 122.45,36.69 122.2,36.94 v8(121.54,36.94) 121.52,36.92 v8(121.52,36.32) ; v8(66.36,42.41) 67.02,42.41 v9(67.18,42.26) ; v8(68.57,47.56) 68.57,47.72 v9(68.42,47.87) ; v9(106.69,39.53) 106.75,39.47 v8(107.03,39.47) ; v8(110.96,41.58) 110.96,41.4 v9(110.83,41.27) ; v8(76,46.24) 76.19,46.24 v9(76.37,46.07) 76.19,45.89 v8(75.99,45.89) ; v8(118.36,49.36) 118.36,49.27 v9(118.74,48.88) ; v9(109.75,37.64) 110.44,38.34 v8(110.94,38.34) ; v9(106.1,32.87) 106.14,32.82 v8(106.53,32.82) ; v9(112.21,43.16) 112.23,43.14 v8(112.23,42.14) v8(112.23,41.57) ; v9(74.52,43.07) 74.44,43.14 v8(73.98,43.14) ; v8(66.46,47.92) 66.46,47.69 v9(66.26,47.49) ; v8(52.39,12.41) 52.39,12.58 v9(52.65,12.84) ; v8(124.81,48.04) 124.89,48.04 v9(125.37,48.52) ; v8(112.95,38.12) 112.86,38.12 v9(112.57,37.83) 112.28,38.12 v8(112.08,38.12) ; v9(71.65,39.74) 71.77,39.87 v8(71.77,40.05) ; v8(119.83,47.58) v9(119.4,47.58) ; v8(107.03,40.29) 107.03,40.41 v9(106.81,40.64) 107.04,40.87 v8(107.04,41.04)
  GND2 w0.254: v9(68.76,45.99) 68.63,46.12 v8(68.63,46.45) ; v9(117.62,34.68) 117.79,34.51 v8(118.28,34.51) ; v8(107.03,38.64) 107,38.64 v9(106.67,38.31) 107.03,37.95 v8(107.03,37.88) ; v8(138.38,37.07) 138.38,36.79 v9(138.14,36.56) 138.14,36.55 v8(138.14,36.08) ; v9(124.61,48.57) 124.66,48.63 v8(124.66,48.97) ; v9(126.18,48.32) 125.94,48.08 v8(125.6,48.08) ; v8(118.93,47.58) 118.75,47.58 v9(118.56,47.38)
  IN4 w0.071: 243.02,26.96 243.02,27.26 242.89,27.39 v8(242.89,27.59)
  BOTTOM w0.102: v13(145.8,40.54) 145.87,40.54 U7A1.D8
  BOTTOM w0.117: PU19.3 v8(176.96,14.98)
  BOTTOM w0.178: v4(190.09,22.52) 190.11,22.55 PU13.11 ; 79.17,29.1 PU9.11 ; PU22.11 188.72,10.14 v8(188.84,10.27) ; v8(68.63,43.4) 68.76,43.4 69.24,43.88 69.85,43.88 70.02,44.05 PR124.1 ; R176.1 124.54,48.85 v8(124.66,48.97)
  BOTTOM w0.203: v13(101.4,14.96) 101.72,15.28 U4A1.T3 ; v13(103.35,17.35) 103.67,17.67 U4A1.N6 ; PR247.2 186.86,21.78 186.66,21.58 v4(186.3,21.58) 186.07,21.58 185.39,22.25 PC175.1 ; v4(68.17,27.37) 67.98,27.56 PC146.2 PC145.2 ; U5A1.F12 125.99,22.82 125.99,22.83 125.99,23.11 126.41,23.53 v13(126.49,23.53) 127.1,23.53 127.2,23.43 127.2,22.92 127.29,22.82 U5A1.D12 ; PC99.2 65.53,45.6 v8(65.3,45.84) ; U6A1.B5 148.49,24.18 v13(148.14,23.84) ; U4A1.L6 104.97,17.67 v13(104.65,17.35) ; U5A1.G8 125.66,19.62 v13(125.66,19.71) ; U5A1.F5 126.29,16.6 v13(126.29,16.54) 125.99,16.24 U5A1.F4 ; v4(244.95,11.8) 244.47,12.29 C380.2 ; v13(149.77,32.69) 150.05,32.41 U7A1.T3 ; v13(149.77,32.69) U7A1.R4 ; v13(149.77,32.69) 149.67,32.69 U7A1.T4 ; C310.2 C311.2 v4(51.99,22.82) ; v4(157.8,21.95) 157.8,21.95 157.97,21.78 158.05,21.78 158.32,21.52 PR251.2 ; PR283.1 178.48,17.12 177.92,17.68 ; v13(148.14,35.34) 147.82,35.66 U7A1.L6 ; v4(195.32,9.76) 195.32,9.89 195.16,10.04 PR516.2 ; U7A1.R6 147.82,33.06 v13(148.14,32.74) ; U4A1.E6 108.87,17.69 v13(108.54,17.36) 108.54,17.4 108.25,17.69 U4A1.F6 ; v4(184.14,10.54) 184.22,10.62 PC248.1 ; U6A1.F6 147.81,21.58 v13(148.13,21.9) ; U5A1.B6 128.59,17.68 v13(128.91,17.36) ; v13(150.57,37.98) 150.63,37.98 U7A1.H2 ; C330.2 v4(47.42,19.78) ; v13(149.78,39.83) 149.69,39.83 149.42,39.56 U7A1.E4 ; v4(245.74,16.75) 245.43,16.44 C357.2 ; C332.2 v4(49.04,19.78) ; U4A1.M4 104.32,16.07 v13(104,15.75) ; U6A1.K2 151.41,18.57 v13(152.77,18.57) ; v13(148.18,22.53) 148.09,22.53 U6A1.E6 ; PR226.2 61.86,24.04 61.95,23.96 PR234.1 62.57,24.2 62.92,24.55 v4(63.06,24.55) 63.25,24.74 PR225.2 ; U5A1.R4 U5A1.T4 119.49,15.95 v13(119.25,15.7) 119.49,15.46 U5A1.T3 ; v13(111.14,16.56) 110.82,16.88 U4A1.B5 ; v13(102.05,16.56) 102.37,16.88 U4A1.R5 ; U5A1.H10 125.05,20.54 v13(125.05,20.5) ; v13(148.93,21.9) 148.61,21.58 U6A1.F5 ; U5A1.T2 119.93,14.94 v13(120.47,14.94) 120.79,15.26 U5A1.P3 ; U5A1.J4 124.04,16.22 v13(124.37,16.55) ; R482.1 55.12,4.91 v4(54.63,5.39) ; v13(148.93,39.23) 148.61,38.91 U7A1.F5 ; C464.1 246.43,3.57 v4(246.06,3.21) ; U4A1.J12 106.27,22.87 106.87,23.47 v13(107.3,23.47) 107.69,23.47 108.1,23.07 108.1,22.62 U4A1.F12 ; C374.2 249.72,13.82 C365.2 ; v4(195.45,24.11) 195.39,24.17 PC158.2 PC170.2 ; U5A1.C6 v13(128.32,17.32) ; PR221.2 184.95,25.27 PC157.1 v8(186.48,25.27) ; 177.92,17.68 177.92,18.07 v4(178.18,18.33) ; 177.92,17.68 PR281.2 ; U4A1.L8 104.97,19.07 v13(105.23,18.81) ; v13(127.59,19.71) 127.42,19.53 127.42,19.5 127.29,19.38 U5A1.D8 ; C170.2 110.76,41.79 v8(110.96,41.58) ; PC140.2 184.23,28.06 183.96,27.8 183.95,27.8 183.91,27.75 183.61,27.75 v4(183.28,27.42) ; U5A1.T6 119.22,17.42 v13(119.22,17.33) 119.49,17.06 U5A1.T5 ; v13(111.14,17.36) 110.82,17.68 U4A1.B6 ; v5(68.67,9.99) 68.67,11.43 69.3,12.06 PC229.1 ; v8(111.83,39.22) C211.2 ; PC139.2 171.52,28.54 v4(171.32,28.34) 171.28,28.22 PC141.1 171.28,27.64 171.68,27.24 171.69,27.24 171.86,27.07 PC147.2 ; PR276.2 64.87,18.1 v4(64.84,18.07) ; v4(124.35,14.1) 124.69,14.44 U5A1.H2 ; v13(148.14,15.41) 147.82,15.73 U6A1.R6 ; U6A1.C3 150.21,23.53 v13(150.54,23.86) 150.86,24.18 U6A1.B2 ; U4A1.T6 101.72,17.67 v13(101.4,17.35) ; C385.2 10.71,17.81 v4(10.74,17.79) ; v13(145,35.97) 144.94,35.97 U7A1.K10 ; R347.2 253.49,18.68 v4(253.36,18.8) ; PR227.2 158.21,23.53 v8(156.89,23.53) ; v13(148.14,32.74) 148.45,32.44 148.54,32.44 148.56,32.41 U7A1.T5 ; v13(148.14,32.74) 148.46,33.06 U7A1.R5 ; v13(148.14,32.74) 147.81,32.41 U7A1.T6 ; PC227.2 82.29,14.31 v4(82.44,14.46) ; v8(164.69,27.21) 164.69,27.19 164.51,27.01 PC148.2 ; U6A1.T6 147.82,15.08 v13(148.14,14.76) ; PC201.1 181.98,18.21 181.98,18.22 PR273.1 183.18,18.22 v4(183.84,18.89) 184.61,18.13 PC206.1 ; PC198.1 178.18,18.38 v4(178.18,18.33) ; PC209.2 64.49,17.73 v4(64.84,18.07) ; U4A1.M12 104.32,22.66 105.13,23.46 v13(105.25,23.46) ; v13(123.07,14.15) 123.39,14.47 U5A1.K2 ; v4(186.28,16.34) 186.14,16.2 PR300.1 ; U4A1.T12 101.72,22.63 v13(101.45,22.9) ; v13(126.29,17.31) 126.29,17.4 U5A1.F6 ; U7A1.T2 151.27,32.14 v13(151.38,32.14) ; R442.2 v4(15.55,8.65) ; v4(55.24,19.08) 55.24,18.35 55.62,17.97 55.62,17.63 55.39,17.41 R362.1 ; U7A1.N5 148.6,34.36 v13(148.93,34.69) 148.61,35.01 U7A1.M5 ; R144.1 109.76,57.74 C41.2 ; v4(213.23,11.92) 213.23,11.85 213.41,11.67 PR499.1 ; U7A1.M6 147.82,35.01 v13(148.14,34.69) 147.81,34.36 U7A1.N6 ; 156.94,27.95 157.86,27.95 157.91,27.9 PR195.1 ; PR207.2 186.08,26.57 186.54,26.11 v8(186.54,25.9) 186.49,25.96 PC150.2 ; C291.2 v8(123.11,27.82) ; C352.2 v4(10.33,17) ; v13(119.17,22.9) 119.49,22.58 U5A1.T12 ; R426.2 v4(17.11,9.29) ; U14.9 v8(232.28,24.87) ; C229.1 C234.1 116.26,37.73 116.28,37.72 C236.1 v8(116.96,37.72) v8(117.39,37.72) C237.2 118.19,37.72 v8(118.2,37.73) 118.46,37.73 118.51,37.67 C245.1 ; U7A1.E6 148.09,39.86 v13(148.18,39.86) ; C384.2 242.48,11.39 242.87,11 C415.2 ; v13(123.13,18.83) 123.02,18.94 123.02,19.02 U5A1.L8 122.98,19.53 122.98,19.86 U5A1.L9 123.16,20.51 123.16,20.66 U5A1.K10 ; v8(110.32,45.41) 110.31,45.41 C112.1 ; U4A1.R4 102.37,16.07 v13(102.05,15.75) ; U5A1.G6 125.64,17.4 v13(125.64,17.28) ; U6A1.H2 150.97,20.28 v13(150.6,20.65) 150.48,20.65 U6A1.G3 ; v4(64.84,18.07) 64.47,18.44 PR274.2 ; v13(150.53,14.76) 150.21,15.08 U6A1.T3 ; v13(142.29,16.09) 142.59,16.38 U6A1.P12 ; v4(189.88,8.41) 189.7,8.6 PC250.2 ; v13(107.89,15.76) 108.22,16.09 ; v13(107.89,15.76) 107.57,16.08 U4A1.G4 ; v13(107.89,15.76) 107.57,15.44 U4A1.G3 ; 108.22,16.09 U4A1.F4 ; 108.22,16.09 108.22,16.07 108.49,15.8 v13(108.49,15.71) 108.87,16.09 U4A1.E4 v13(109.25,15.72) 109.25,15.57 U4A1.D3 ; v13(149.74,14.76) 149.42,15.08 U6A1.T4 ; U4A1.C3 110.17,15.26 v4(110.51,14.93) 110.79,14.65 110.79,14.53 U4A1.B2 ; v13(105.3,14.09) 105.62,14.42 U4A1.K2 ; v13(102.05,14.9) 102.05,14.87 101.72,14.54 U4A1.T2 ; U6A1.T12 142.97,15.08 v13(142.59,14.71) ; U7A1.G6 147.81,38.26 v13(148.13,38.58) 147.8,38.91 U7A1.F6 ; v13(148.14,23.84) 147.84,23.53 U6A1.C6 ; v13(148.14,23.84) U6A1.B6 ; v13(148.14,23.84) 148.29,23.69 148.35,23.69 148.51,23.53 U6A1.C5 ; v13(149.78,23.26) 149.95,23.09 149.98,23.09 150.18,22.88 U6A1.D3 ; PU11.11 163.52,26.08 v4(163.64,25.96) ; U5A1.N6 121.44,17.68 v13(121.77,17.35) ; PR175.2 69.75,32.5 v4(69.97,32.27) ; v8(117.75,36.51) C253.2 C252.2 C251.2 ; v13(128.91,22.91) 128.59,22.59 U5A1.B12 ; C438.2 238.81,7.58 v4(238.67,7.44) ; R301.1 v4(156.48,22.8) ; C413.2 64.26,11.45 v4(64.31,11.39) ; U7A1.G4 149.55,38.26 v13(149.81,38.52) 150.07,38.26 U7A1.G3 ; U5A1.N5 121.44,17.02 v13(121.77,17.35) ; v13(103.35,16.56) 103.67,16.88 U4A1.N5 ; U6A1.T2 151.3,14.78 v13(151.4,14.78) ; U6A1.E4 149.25,22.23 v13(148.96,22.53) 148.89,22.53 U6A1.E5 ; PC179.2 195.02,21.5 v4(195.45,21.94) 195.45,21.94 195,22.39 PC173.1 ; v8(66.59,49.62) PR86.2 ; v13(148.96,39.86) 148.89,39.86 U7A1.E5 ; U7A1.C5 148.6,40.89 148.87,41.16 v13(148.96,41.16) ; U4A1.G6 107.57,17.68 v13(107.89,17.36) ; v13(149.73,39.23) 149.41,38.91 U7A1.F4 ; PR320.1 v4(180.16,6.33) ; U7A1.P3 150.05,33.71 U7A1.N4 149.44,34.36 v13(149.74,34.67) U7A1.M4 ; v13(125.59,15.68) 125.59,15.82 125.34,16.07 U5A1.G4 ; v4(81.98,34.15) 81.65,34.48 PC122.2 ; U4A1.J4 105.95,16.42 v13(105.95,16.55) ; U7A1.C6 147.81,40.86 v13(148.13,41.18) ; U5A1.R6 120.14,17.67 v13(119.82,17.35) 120.14,17.03 U5A1.R5 ; v4(53.66,3.83) C456.2 53.46,4.39 C455.2 ; U4A1.M5 104.32,16.88 v13(104,16.56) ; R319.2 v8(247.59,20.46) ; v4(80.46,36.46) 79.83,35.83 PC119.2 ; R247.1 v8(123.77,27.97) ; v4(178.18,18.33) 177.77,18.74 PC199.2 ; PC117.2 PC118.1 78.94,35.87 78.62,36.18 v5(78.58,36.18) ; PR501.1 213.89,10.45 v4(213.61,10.17) ; v13(101.4,15.75) 101.72,16.07 U4A1.T4 ; v13(109.82,19.71) 109.65,19.53 109.65,19.5 109.52,19.38 U4A1.D8 ; v13(121.77,17.35) 122.09,17.67 U5A1.M6 ; U6A1.J4 149.29,19.63 v13(148.95,19.29) ; U5A1.E4 v13(126.97,15.77) 126.97,15.58 127.25,15.29 U5A1.D3 ; U6A1.R4 149.42,15.73 v13(149.74,15.41) ; C44.1 v4(34.52,56.65) ; v13(148.93,15.41) 148.61,15.73 U6A1.R5 ; v4(195.57,20.53) 195.49,20.61 PC186.2 ; R257.1 v8(122.35,27.82) ; v4(57.16,27.71) 57.29,27.32 PR202.2 ; PC101.1 66.72,42.61 66.52,42.41 v8(66.36,42.41) ; U6A1.N5 148.61,17.03 v13(148.93,16.71) 149.25,17.03 U6A1.N4 ; v13(149.73,21.25) 149.41,20.93 U6A1.G4 ; PR189.2 184.76,29.94 184.97,30.14 v4(185.37,30.14) ; PR282.2 PC211.1 171.04,18.2 v4(170.53,18.71) 171.01,19.19 PR270.2 ; U7A1.B6 v13(148.18,41.89) ; U4A1.G9 107.57,20.19 v13(107.27,20.49) 106.92,20.84 U4A1.H10 ; U4A1.R6 102.37,17.67 v13(102.05,17.35) ; v4(102.51,51.86) 102.67,51.7 C58.1 ; v13(125.66,14.96) 125.34,15.28 U5A1.G3 ; v13(124.32,22.89) 124.04,22.62 U5A1.J12 ; U5A1.L6 122.74,17.67 v13(122.42,17.35) 122.09,17.02 U5A1.M5 ; PC204.2 63.22,17.61 v4(63.34,17.49) ; R280.1 156.55,24.53 v8(156.89,24.19) 156.99,24.19 158.23,25.42 PC153.2 ; U6A1.T5 148.61,15.08 v13(148.93,14.76) ; PC166.2 188.72,23.66 188.54,23.48 PC172.2 188.54,22.08 v4(188.59,22.04) PC176.2 PC181.2 ; U6A1.L6 U6A1.M6 U6A1.M5 148.61,17.68 v13(148.93,17.36) 149.25,17.68 U6A1.M4 ; v4(184.7,4.48) 184.62,4.56 PR316.2 ; v13(101.4,16.56) 101.72,16.88 U4A1.T5 ; R373.1 v4(61.01,16.02) ; v13(125.66,20.48) 125.58,20.39 125.58,20.33 U5A1.G9 ; U4A1.C5 v13(110.54,16.53) ; PR513.2 194.91,13.16 195.27,13.52 v4(195.45,13.52) ; C331.2 v4(48.18,19.8) ; v13(148.13,21.25) 147.81,20.93 U6A1.G6 ; R243.1 v4(197.89,15.98) ; PC191.2 62.63,19.37 62.84,19.17 v4(62.99,19.17) ; U6A1.P3 150.26,16.38 v13(150.57,16.08) ; U5A1.E6 v13(127.02,17.32) ; U5A1.P8 120.79,19.43 121.08,19.72 v13(121.1,19.72) ; U5A1.C3 127.94,15.2 v13(128.3,14.85) 128.59,14.55 U5A1.B2 ; v4(69.57,15.53) 69.74,15.36 PC220.1 ; v13(142.59,24.46) 142.87,24.18 U6A1.B12 ; U6A1.N6 147.82,17.03 v13(148.14,16.71) ; C334.2 v4(43.53,19.57) ; v13(104,17.35) 104.32,17.67 U4A1.M6 ; v13(102.78,19.7) 102.78,19.54 U4A1.P8 ; U7A1.K2 v13(151.38,35.93) ; U4A1.P3 103.02,15.28 v13(102.7,14.96) ; C335.2 v4(44.42,19.65) ; v13(149.73,21.9) 149.41,21.58 U6A1.F4 ; v4(106.57,13.95) 106.92,14.3 U4A1.H2 ; U5A1.C5 v13(128.31,16.53) ; U4A1.K10 105.39,20.66 105.39,20.51 U4A1.L9 104.67,20.4 v13(104.67,20.48) ; R143.1 v8(104.82,58.71) ; v13(128.91,16.56) 128.59,16.88 U5A1.B5 ; v13(103.35,15.75) 103.67,16.07 U4A1.N4 ; U7A1.P8 145.84,33.36 v13(145.84,33.36) ; v13(103.42,23.48) 103.15,23.48 102.85,23.18 102.85,22.66 U4A1.P12 ; PR116.1 68.63,45.41 v8(68.63,46.45) ; PR324.1 v4(213.71,20.02) ; U4A1.C6 v13(110.5,17.37) ; U7A1.B5 v13(148.96,41.88) ; U5A1.E5 v13(127.01,16.53) ; v13(107.89,19.71) 107.57,19.39 U4A1.G8 ; R305.2 v8(247.59,22.11)
  BOTTOM w0.254: CN9.1 v4(16.05,14.71) ; C282.2 245.05,21.75 v4(245.15,21.65) ; v13(145.84,16.7) 145.89,16.7 U6A1.P8 ; U6A1.L8 146.2,18.3 145.89,17.99 v13(145.86,17.99) ; U17.F5 52.67,11.41 52.65,11.39 v4(52.41,11.39) U17.G5 U17.H5 ; v8(104.77,40.47) 104.87,40.57 C480.1 104.56,40.66 v8(104.36,40.47) ; PU10.3 v8(73.98,28.12) ; U7A1.L9 145.06,35.32 v13(144.99,35.32) ; PQ22.4 213.59,10.15 v4(213.61,10.17) ; U7A1.L8 145.86,35.32 v13(145.83,35.32) ; v4(151.44,41.16) 151.09,41.51 U7A1.B2 ; U7A1.J4 149.53,36.96 149.75,36.73 v13(149.8,36.73) ; U17.G4 53.59,11.12 v4(53.87,11.12) ; CN17.4 167.85,7.64 167.68,7.47 167.68,7.37 v4(167.66,7.35) ; CN9.10 20.55,15.85 v4(21.24,16.54) ; U7A1.C3 150.22,40.86 v13(150.53,40.55) U7A1.D3 ; v4(19.05,15.73) CN9.7 ; PQ15.4 213.37,20.36 v4(213.71,20.02) ; Q16.1 44.18,28.55 v4(44.57,28.16) ; U4A1.E5 108.87,16.75 108.62,16.5 ; U6A1.M12 142.7,17.68 v13(142.52,17.86) ; 108.62,16.5 U4A1.F5 ; 108.62,16.5 v13(108.64,16.5) ; v4(17.55,15.48) CN9.4 ; U9.6 v8(89.53,28.08) ; U6A1.K10 144.9,18.68 145.05,18.68 U6A1.L9 145.06,17.99 v13(144.99,17.99) ; v4(42.29,30.34) 42.63,30.34 42.88,30.6 Q16.4
  BOTTOM w0.279: PQ15.1 v4(212.07,24.17)
  BOTTOM w0.305: v4(26.05,12.99) CN9.21 ; v4(4.64,14.25) CN10.5 ; CN9.24 27.55,14.48 v4(27.78,14.71) 28.05,14.44 CN9.25 ; v8(240.67,28.05) 240.53,27.91 U15.11 ; v4(237.99,23.96) 238.15,24.12 U15.5 ; CN10.3 v4(4.64,13.25) ; U44.3 v4(193.68,6.52)
  BOTTOM w0.381: v4(197.86,49) 199.03,49 199.26,48.78 C55.2 C60.1 ; v4(3.75,20.94) 3.61,20.8 CN8.4 ; D16.2 v4(5.77,21.32) ; CN17.10 v4(164.85,4.83) ; C731.1 171.63,10.62 v4(172.05,10.62) 172.05,9.91 171.61,9.47 D50.1 ; v4(244.31,4.18) 244.7,3.79 C460.2 ; D49.1 v4(174.12,8.59) ; v4(3.78,21.7) 3.6,21.7 3.3,21.4 CN8.5 ; PC231.2 44.37,11.38 v4(44.27,11.48) ; C457.1 C466.2 233.18,2.37 v4(233.11,2.29) ; v4(42.29,30.34) 41.98,30.04 C277.2 ; PC93.2 77.52,47.54 v4(77.79,47.82) ; v4(109.55,59.55) 110.17,58.94 C41.2 ; v5(59.92,45.73) 59.28,45.73 59.15,45.6 PC94.2 ; Q22.1 47.67,23.97 v4(48.08,24.38) 47.8,24.66 R282.1 ; v4(50.34,39.82) PC100.1 ; v4(5.37,18.49) 5.75,18.87 D17.2 ; v4(146.99,11.92) 146.99,11.36 C7L12.1 ; D14.2 194.77,51.79 v4(194.96,51.59) ; CN7.5 252.73,34.4 v4(252.88,34.25) 253.2,33.93 C262.1 ; D25.2 D26.2 212.3,3.56 v4(212.1,3.77) ; v4(196.31,50.68) 196.72,50.68 196.9,50.86 CN6.1 ; C432.1 234.32,7.85 v4(234.23,7.94) ; C67.2 199.28,47.99 198.91,48.36 v4(198.12,48.36) ; v4(4.57,11.25) CN10.7 ; D33.2 v4(11.04,7.3) ; v4(157.93,4.63) 157.95,4.65 CN16.10 ; SW1.3 v4(39.37,59.44) ; D37.2 v4(11.88,4.55) ; SW1.4 v4(36.42,59.42) ; v4(150.88,11.95) C4A5.1 ; D15.2 194.87,54.45 v4(194.99,54.57) ; v4(4.57,15.75) CN10.8 ; v4(148.19,11.95) C4A4.1 ; C348.2 v4(50.01,18.51) ; CN16.9 v4(163.45,4.83) ; CN17.9 v4(170.35,4.83)
  BOTTOM w0.406: C950.2 v4(229.1,22.08) ; C949.2 v4(227.07,21.06) ; C284.1 C289.2 v4(196.45,16.55) ; PC242.2 201.03,10.83 v4(201.44,11.23) 201.03,11.64 PC243.1 ; C952.1 v4(229.1,23.1) ; v4(229.23,24.49) 228.85,24.11 C951.1 ; v4(225.29,14.84) 225.05,14.6 C429.2 ; C943.1 v4(229.1,19.03) 229.1,18.55 228.57,18.02 R10983.2 ; R10995.1 v4(227.07,20.05)
  BOTTOM w0.508: v4(64.66,6.81) 64.31,7.17 Q31.1 ; PC110.2 64.75,37.83 64.61,37.68 v8(64.61,37.33) ; C295.2 84.03,25.03 84.23,24.84 v4(84.23,24.47) ; SW3.1 61.46,4.84 v4(61.46,3.97) ; v4(191.71,5.93) 191.34,5.55 PC255.2 190.87,4.96 v4(191.08,4.76) ; C5L1.2 v8(156.91,34.38) ; R309.2 231.44,21.06 231.26,20.88 v4(231.26,20.81) ; v8(74.01,31.03) 74.05,30.99 PC127.2 ; v4(238.37,8.17) 238.64,8.45 C431.2 ; v4(238.67,7.44) C444.1 ; PU21.2 198.62,11.54 v4(198.49,11.41) ; C442.1 16.66,6.52 17.06,6.92 v4(17.06,7.3) ; C359.2 64.66,15.59 v4(65.21,16.13) ; C5L2.2 v8(156.86,31.96) ; C364.2 62.31,14.23 62.61,13.93 v4(63.01,13.93) ; v8(246.57,14.95) 246.17,14.55 R402.1 C370.1 C371.2 ; R434.1 v4(61.39,9.13) ; C360.1 v4(37.37,16.31) ; C375.2 C384.2 242.06,12.13 v4(241.73,11.79) ; D8.2 v4(183.67,54.12) ; v4(44.06,22.26) 43.83,22.49 Q21.1 ; v4(168.33,26.46) 168.33,26.47 168.86,27 PR201.2 ; C288.1 42.72,26.46 v4(42.44,26.18) ; R6L2.1 v8(156.84,28.95) ; 181.15,54.19 v4(181.15,54.14) ; 181.15,54.19 180.64,54.7 D6.2 ; 181.15,54.19 181.66,54.7 D7.2 ; C209.1 156.26,39.23 156.97,39.23 v8(156.99,39.26) ; PC130.2 158.67,29.42 v8(159.07,29.01) ; PC215.2 67.87,16.49 PC214.1 v4(67.22,16.49) ; v4(46.76,8.64) 46.76,8.97 46.33,9.4 C433.2 ; PC193.1 192.36,19.51 192.02,19.16 v4(192.02,18.65) ; v4(20.23,10.85) 20.24,10.85 C386.2 ; C6L5.2 C5L5.2 114.6,9.1 ; v4(201.67,28.68) C306.2 ; C6L1.2 157.04,38.19 ; R475.2 239.9,5.43 239.74,5.59 v4(239.73,5.59) 239.58,5.43 R474.2 238.92,5.43 v4(238.5,5.86) ; PC129.2 v8(83.28,29.3) ; PC223.2 182.24,6.32 v4(182.77,5.79) ; C315.1 238.88,20.68 v4(238.3,20.1) 238.6,19.79 C373.1 ; C111.2 191.61,44.02 C130.2 191.61,44 191.61,42.98 C145.2 v4(193.49,42.96) ; Q17.1 v4(39.44,25.61) ; v4(33.93,24.54) 33.93,25.18 34.08,25.33 PR208.2 ; CL1_CL2.1 v4(66.91,5.65) ; v4(234.51,3.34) 234.89,3.72 U21.2 ; PC232.2 180.45,7.02 180.16,6.72 v4(180.16,6.33) ; PC162.2 v4(177.29,11.28) ; v4(187.29,6.1) 187.76,6.1 PC256.2 187.76,6.81 v4(187.32,6.81) ; C303.2 156.3,23.53 v8(156.89,23.53) ; v4(250.12,14.87) 250.14,14.85 C365.2 ; D11.2 191.26,54.44 v4(190.9,54.08) ; D13.2 v4(185.58,54.1) ; v4(62.86,16.81) C353.1 ; D12.2 v4(193.19,54.11) ; PU16.2 181.93,7.81 v4(181.73,7.6) ; R494.2 243.5,3.3 v4(243.25,3.55) ; C5L3.2 156.87,30.9 ; v4(195.32,9.76) 195.32,9.13 C957.2 ; C956.1 v4(195.95,9.76) ; C350.2 46.27,16.63 v4(46.53,16.37) ; v4(71.54,58.08) 72.13,57.49 PC81.1 ; v4(198.49,9.89) 198.87,9.52 C954.1 ; C369.2 37.15,14.12 37.15,13.11 ; C953.1 217.42,18.09 v4(217.11,18.4) ; PC161.2 v4(176.27,11.28) ; v4(247.77,16.72) v4(248.41,16.72) 249.14,16.72 249.47,17.05 C344.2 C345.2 ; Q23.1 42.16,18.76 v4(41.47,19.45) ; v4(21.12,10.86) C387.1 ; v4(237.23,26.52) 237.13,26.42 C314.1 C329.1 ; PC241.2 195.45,10.7 v4(195.5,10.65) ; D9.2 v4(187.47,54.11) ; v4(34.05,19.18) CN9.34 ; PC188.1 169.63,20.23 169.38,20.48 PR255.1 v4(168.05,20.48) ; C6L2.2 v8(156.89,29.91) ; CN9.33 13.17,18 v4(12.17,19) ; R365.2 v4(231.26,20.05) ; C6A1.2 157.07,37.18 ; 156.5,35.7 157.37,35.7 ; v4(64.31,11.39) 65.12,12.21 PD6.2 PD3.2 ; SW3.2 58.35,4.89 v4(57.8,4.33) 57.15,3.68 C470.1 ; C6A4.2 v8(156.89,32.97) ; PU17.2 v4(196.08,30.84) ; R6L3.1 156.94,27.93 ; C358.1 v4(8.62,14.22) ; D10.2 v4(188.44,54.11)
  vias: v1(45.94,49.87) v1(60.45,41.97) v1(64.56,37.23) v1(66.19,47.15) v1(66.19,43.7) v1(66.52,47.23) v1(66.54,43.73) v1(68.52,46.23) v1(68.52,45.73) v1(68.52,45.23) v1(68.52,44.73) v1(69.02,46.23) v1(69.02,45.73) v1(69.02,45.23) v1(69.02,44.73) v1(69.52,46.23) v1(69.52,45.73) v1(69.52,45.23) v1(69.52,44.73) v1(69.52,42.74) v1(69.52,42.48) v1(69.52,42.23) v1(69.52,41.98) v1(70.02,45.73) v1(70.02,45.23) v1(70.02,44.73) v1(71.02,42.23) v1(72.1,45.23) v1(72.47,46.73) v1(72.52,45.23) v1(72.84,46.72) v1(97.05,48.52) v1(98.04,48.53) v1(98.18,48.97) v1(98.41,50.42) v1(98.65,48.53) v1(98.67,48.94) v1(99.18,48.5) v1(99.28,48.94) v1(99.77,42.03) v1(100.27,46.8) v1(100.35,47.69) v1(100.76,46.78) v1(100.86,47.67) v1(101.24,46.8) v1(101.39,47.69) v1(102.09,45.27) v1(102.81,34.13) v1(102.81,31.62) v1(104.01,34.14) v1(104.69,40.29) v1(108.27,37.63) v1(108.73,46.68) v1(108.73,44.05) v1(109.64,45.71) v1(109.84,44.1) v1(110.04,39.27) v1(110.53,39.27) v1(110.78,40.88) v1(111.27,42.17) v1(111.48,48.87) v1(111.48,46.41) v1(111.8,47.15) v1(111.75,42.04) v1(111.75,40.92) v1(111.75,39.25) v1(112.04,52.93) v1(112.12,48.38) v1(112.25,44.28) v1(112.25,42.04) v1(112.25,40.92) v1(112.25,40.37) v1(112.22,39.76) v1(112.45,47.15) v1(112.74,43.16) v1(112.77,48.33) v1(113.09,47.15) v1(113.24,39.81) v1(113.73,40.37) v1(113.73,38.03) v1(114.06,48.38) v1(114.7,48.38) v1(114.7,41.46) v1(114.7,40.93) v1(114.67,40.34) v1(114.7,39.81) v1(115.02,47.17) v1(115.67,47.15) v1(115.72,44.84) v1(115.74,44.28) v1(115.72,43.72) v1(115.72,43.19) v1(115.74,41.51) v1(115.72,38.69) v1(115.77,40.93) v1(115.77,40.37) v1(115.79,39.81) v1(115.77,39.17) v1(115.98,37.88) v1(116.63,48.38) v1(116.71,45.96) v1(116.71,44.84) v1(116.71,43.72) v1(116.71,42.6) v1(116.71,41.49) v1(116.71,39.25) v1(116.65,37.89) v1(117.28,48.38) v1(117.28,37.79) v1(117.65,40.93) v1(117.65,40.37) v1(117.7,45.96) v1(117.7,43.16) v1(117.7,42.04) v1(117.7,41.51) v1(117.72,39.71) v1(117.7,39.28) v1(117.9,37.78) v1(118.55,37.78) v1(118.69,45.96) v1(118.71,43.72) v1(118.69,42.02) v1(118.69,41.54) v1(118.69,40.93) v1(118.71,40.34) v1(118.71,39.78) v1(119.2,37.79) v1(119.68,45.95) v1(119.69,45.4) v1(119.68,44.79) v1(119.68,44.29) v1(119.71,43.72) v1(119.68,43.13) v1(119.7,42.04) v1(119.7,41.51) v1(119.7,40.93) v1(119.7,40.37) v1(119.68,39.78) v1(119.86,37.77) v1(120.5,37.78) v1(120.66,45.97) v1(120.67,43.72) v1(120.67,42.6) v1(120.69,41.49) v1(120.69,40.38) v1(121.15,37.79) v1(121.17,45.96) v1(121.16,43.72) v1(121.16,42.6) v1(121.15,41.47) v1(121.16,40.36) v1(121.16,39.25) v1(121.65,40.37) v1(121.66,44.84) v1(121.66,43.72) v1(121.75,41.51) v1(121.68,39.24) v1(121.78,37.89) v1(122.11,43.72) v1(122.14,41.48) v1(122.15,44.84) v1(122.16,40.39) v1(122.26,39.26) v1(122.42,37.87) v1(122.65,44.84) v1(122.64,39.25) v1(122.72,43.73) v1(122.68,41.45) v1(122.69,40.38) v1(123.15,44.84) v1(123.15,43.72) v1(123.14,40.34) v1(123.08,37.89) v1(123.15,39.21) v1(123.64,44.84) v1(123.65,40.37) v1(123.71,39.2) v1(123.72,37.78) v1(124.73,54.29) v1(124.91,42.17) v1(125.41,42.17) v1(125.71,48.26) v1(125.65,43.79) v1(125.9,42.17) v1(126.14,43.78) v1(126.39,42.17) v1(126.48,48.53) v1(126.48,48.05) v1(126.63,43.78) v1(126.91,42.17) v1(208.55,17.8) v1(258.44,35.54) v1(267.05,17.51) v2(45.94,49.87) v2(51.48,59) v2(60.45,41.97) v2(64.56,37.23) v2(66.19,47.15) v2(66.19,43.7) v2(66.52,47.23) v2(66.54,43.73) v2(68.52,46.23) v2(68.52,45.73) v2(68.52,45.23) v2(68.52,44.73) v2(69.02,46.23) v2(69.02,45.73) v2(69.02,45.23) v2(69.02,44.73) v2(69.52,46.23) v2(69.52,45.73) v2(69.52,45.23) v2(69.52,44.73) v2(69.52,42.74) v2(69.52,42.48) v2(69.52,42.23) v2(69.52,41.98) v2(70.02,45.73) v2(70.02,45.23) v2(70.02,44.73) v2(71.02,42.23) v2(72.1,45.23) v2(72.47,46.73) v2(72.52,45.23) v2(72.84,46.72) v2(98.04,48.53) v2(98.18,48.97) v2(98.41,50.42) v2(98.65,48.53) v2(98.67,48.94) v2(99.18,48.5) v2(99.28,48.94) v2(99.77,42.03) v2(100.27,46.8) v2(100.35,47.69) v2(100.76,46.78) v2(100.86,47.67) v2(101.24,46.8) v2(101.39,47.69) v2(102.09,45.27) v2(102.81,34.13) v2(102.81,31.62) v2(104.01,34.14) v2(104.69,40.29) v2(108.27,37.63) v2(108.73,46.68) v2(108.73,44.05) v2(109.64,45.71) v2(109.84,44.1) v2(110.04,42.49) v2(110.04,39.27) v2(110.53,39.27) v2(110.78,40.88) v2(111.27,42.17) v2(111.48,48.87) v2(111.48,46.41) v2(111.8,47.15) v2(111.75,42.04) v2(111.75,40.92) v2(111.75,39.25) v2(112.04,52.93) v2(112.12,48.38) v2(112.25,44.28) v2(112.25,42.04) v2(112.25,40.92) v2(112.25,40.37) v2(112.22,39.76) v2(112.45,47.15) v2(112.74,43.16) v2(112.77,48.33) v2(113.09,47.15) v2(113.24,39.81) v2(113.73,40.37) v2(113.73,38.03) v2(114.06,48.38) v2(114.7,48.38) v2(114.7,41.46) v2(114.7,40.93) v2(114.67,40.34) v2(114.7,39.81) v2(115.02,47.17) v2(115.67,47.15) v2(115.72,44.84) v2(115.74,44.28) v2(115.72,43.72) v2(115.72,43.19) v2(115.74,41.51) v2(115.72,38.69) v2(115.77,40.93) v2(115.77,40.37) v2(115.79,39.81) v2(115.77,39.17) v2(116.63,48.38) v2(116.71,45.96) v2(116.71,44.84) v2(116.71,43.72) v2(116.71,42.6) v2(116.71,41.49) v2(116.71,39.25) v2(117.28,48.38) v2(117.28,37.79) v2(117.65,40.93) v2(117.65,40.37) v2(117.7,45.96) v2(117.7,43.16) v2(117.7,42.04) v2(117.7,41.51) v2(117.72,39.71) v2(117.7,39.28) v2(117.9,37.78) v2(118.55,37.78) v2(118.69,45.96) v2(118.71,43.72) v2(118.69,42.02) v2(118.69,41.54) v2(118.69,40.93) v2(118.71,40.34) v2(118.71,39.78) v2(119.2,37.79) v2(119.68,45.95) v2(119.69,45.4) v2(119.68,44.79) v2(119.68,44.29) v2(119.71,43.72) v2(119.68,43.13) v2(119.7,42.04) v2(119.7,41.51) v2(119.7,40.93) v2(119.7,40.37) v2(119.68,39.78) v2(119.86,37.77) v2(120.5,37.78) v2(120.66,45.97) v2(120.67,43.72) v2(120.67,42.6) v2(120.69,41.49) v2(120.69,40.38) v2(121.15,37.79) v2(121.17,45.96) v2(121.16,43.72) v2(121.16,42.6) v2(121.15,41.47) v2(121.16,40.36) v2(121.16,39.25) v2(121.65,40.37) v2(121.66,44.84) v2(121.66,43.72) v2(121.75,41.51) v2(121.68,39.24) v2(121.78,37.89) v2(122.11,43.72) v2(122.14,41.48) v2(122.11,37.04) v2(122.15,44.84) v2(122.16,40.39) v2(122.26,39.26) v2(122.42,37.87) v2(122.65,44.84) v2(122.64,39.25) v2(122.72,43.73) v2(122.68,41.45) v2(122.69,40.38) v2(123.15,44.84) v2(123.15,43.72) v2(123.14,40.34) v2(123.08,37.89) v2(123.15,39.21) v2(123.64,44.84) v2(123.65,40.37) v2(123.71,39.2) v2(124.73,54.29) v2(124.91,42.17) v2(125.41,42.17) v2(125.71,48.26) v2(125.9,42.17) v2(126.39,42.17) v2(126.48,48.53) v2(126.48,48.05) v2(126.91,42.17) v2(128.14,36.68) v2(128.14,35.8) v2(129.03,36.68) v2(129.03,35.8) v2(129.91,36.68) v2(129.91,35.8) v2(160.06,14.16) v2(160.06,11.31) v2(162.3,13.85) v2(163.01,11.31) v2(208.55,17.8) v2(233.04,24.49) v2(258.44,35.54) v2(267.05,17.51) v3(60.45,41.97) v3(267.05,17.51) v4(8.76,12.12) v4(16.48,18.68) v4(20.29,14.36) v4(20.76,7.23) v4(21.5,7.23) v4(22.23,7.25) v4(26.92,12.99) v4(27.55,12.99) v4(28.19,12.99) v4(28.82,12.99) v4(29.46,12.99) v4(30.09,12.99) v4(30.73,12.99) v4(31.36,12.99) v4(32,12.99) v4(37.56,17.08) v4(37.99,22.71) v4(38.19,21.41) v4(39.36,21.59) v4(40.7,7.28) v4(41.33,7.28) v4(41.97,58.75) v4(41.97,7.28) v4(44.95,53.07) v4(45.92,50.88) v4(47.31,28.18) v4(48.82,27.33) v4(49.14,35.08) v4(49.17,34.45) v4(49.37,26.52) v4(53.31,47.07) v4(56.94,32.09) v4(60.47,20.97) v4(64.18,48.96) v4(68.19,54.31) v4(68.19,53.68) v4(68.19,53.04) v4(68.83,54.31) v4(68.83,53.68) v4(68.83,53.04) v4(69.21,32.27) v4(72.1,25.15) v4(72.18,14.92) v4(78.26,32.06) v4(78.91,28.35) v4(79.17,32.1) v4(79.34,36.48) v4(79.95,32.09) v4(80.13,28.46) v4(81.78,56.65) v4(82.21,57.46) v4(82.9,51.75) v4(83.28,20.39) v4(83.28,19.65) v4(83.66,56.67) v4(88.06,44.74) v4(88.82,44.74) v4(89.55,26.04) v4(89.68,44.74) v4(91.61,50.35) v4(95.45,24.11) v4(97.81,12.89) v4(97.76,10.94) v4(98.27,10.45) v4(106.45,39.94) v4(106.58,8.14) v4(107.26,8.14) v4(107.28,3.77) v4(107.92,8.13) v4(108.82,8.13) v4(109.51,51.31) v4(109.51,8.15) v4(109.82,3.77) v4(109.98,39.15) v4(110.23,52.01) v4(110.16,51.27) v4(110.18,8.14) v4(111.07,49.66) v4(111.35,8.13) v4(112,8.13) v4(112.36,3.77) v4(112.68,8.15) v4(112.77,53.13) v4(112.77,52.49) v4(112.77,51.86) v4(113.25,8.95) v4(113.61,8.14) v4(114.29,8.13) v4(114.94,8.13) v4(114.9,3.77) v4(115.88,8.15) v4(116.55,8.14) v4(117.44,3.77) v4(119.98,3.77) v4(122.52,3.77) v4(123.31,8.14) v4(123.96,8.15) v4(124.64,8.15) v4(125.06,3.77) v4(125.32,8.14) v4(127.6,3.77) v4(131.34,54.4) v4(131.59,35.75) v4(131.71,13.04) v4(132.33,54.4) v4(132.51,52.33) v4(133.34,54.4) v4(133.83,19.01) v4(133.78,14.69) v4(134.26,54.4) v4(134.41,19.67) v4(134.59,19.01) v4(134.74,16.88) v4(134.74,16.19) v4(134.69,15.48) v4(134.92,20.86) v4(135.12,54.4) v4(135.94,54.42) v4(138.3,52.31) v4(139.64,48.8) v4(147.42,48.41) v4(153,43.59) v4(153.74,55.35) v4(156.05,28.2) v4(156.66,32.34) v4(156.84,16.45) v4(156.84,15.65) v4(157.17,54.22) v4(157.42,17) v4(157.4,16.04) v4(159.22,27.14) v4(163.57,32.52) v4(164.61,49.33) v4(165.47,18.37) v4(167.77,38.12) v4(167.77,37.48) v4(167.77,36.85) v4(167.77,36.21) v4(170.94,50.78) v4(174.64,33.18) v4(175.23,14.1) v4(175.48,36.13) v4(176.4,6.46) v4(177.21,6.92) v4(177.34,25.68) v4(177.34,24.94) v4(177.34,24.2) v4(177.34,23.47) v4(178.05,7.35) v4(178.07,25.68) v4(178.07,24.94) v4(178.07,24.2) v4(178.07,23.47) v4(178.81,25.68) v4(178.81,24.94) v4(178.81,24.2) v4(178.81,23.47) v4(180.69,33.21) v4(181.83,48.88) v4(182.49,50.26) v4(183.13,50.26) v4(183.76,50.26) v4(184.47,50.26) v4(186.33,37.29) v4(187.88,38.13) v4(187.85,37.45) v4(188.46,37.83) v4(189.49,27.02) v4(192.02,23.55) v4(192.02,22.33) v4(192.02,21.7) v4(194.38,42.36) v4(194.63,43.73) v4(196.64,48.88) v4(198.04,41.52) v4(198.65,42.1) v4(199.66,45.6) v4(220.72,22.08) v4(220.72,20.3) v4(220.72,18.65) v4(222.37,22.08) v4(222.37,20.3) v4(222.37,18.65) v4(224.02,22.08) v4(224.02,20.3) v4(224.02,18.65) v4(231.13,18.88) v4(231.21,16.9) v4(231.26,22.99) v4(238.12,21.7) v4(240.28,24.37) v4(240.28,23.22) v4(242.67,21.42) v4(243.2,19.64) v4(243.63,26.73) v4(245.18,25.23) v4(246.04,10.35) v4(246.02,8.47) v4(246.02,6.59) v4(247.92,10.38) v4(247.95,8.47) v4(247.97,6.57) v4(249.83,8.45) v4(249.85,10.38) v4(249.88,6.57) v4(250.08,34.93) v4(250.56,24.62) v4(250.56,22.97) v4(250.56,21.19) v4(251.35,29.6) v4(251.99,29.45) v4(251.96,17.13) v4(252.22,24.75) v4(252.22,22.97) v4(252.22,21.19) v4(253.66,15.15) v4(253.87,17.38) v4(254.63,17.38) v4(254.55,15.15) v4(254.68,34.4) v4(255.49,15.15) v4(256.43,15.15) v4(265.04,34.22) v4(266.44,27.54) v4(267.2,27.67) v4(267.33,28.68) v4(267.51,23.1) v4(271.22,39.81) v5(0.91,20.59) v5(0.86,15.05) v5(0.91,12.36) v5(0.97,16.8) v5(1.11,24.58) v5(3.55,24.62) v5(4.82,1) v5(6.19,24.58) v5(8.12,0.98) v5(8.73,24.58) v5(11.27,24.58) v5(11.3,1) v5(13.81,24.58) v5(14.09,1) v5(14.22,4.05) v5(16.35,24.58) v5(17.77,4.05) v5(18.89,24.58) v5(20.64,4.1) v5(21.43,24.58) v5(23.18,4.1) v5(23.97,24.58) v5(25.72,4.1) v5(26.36,24.62) v5(28.26,4.1) v5(29.31,24.52) v5(30.8,4.1) v5(30.91,60.92) v5(30.88,54.59) v5(31.74,30.51) v5(31.74,28.58) v5(31.74,24.52) v5(31.85,26.45) v5(32.58,61.03) v5(33.34,4.1) v5(35,30.51) v5(35.5,61.05) v5(35.6,53.88) v5(35.88,4.1) v5(38.42,4.1) v5(40.58,61.05) v5(40.96,4.1) v5(43.12,61.05) v5(43.66,4.1) v5(45.66,61.05) v5(47.01,59.65) v5(47.11,4.05) v5(48.2,61.05) v5(48.43,59.62) v5(49.83,59.62) v5(50.74,61.05) v5(51.1,59.65) v5(52.44,59.65) v5(52.83,46.5) v5(52.83,45.77) v5(53.28,61.05) v5(53.33,34.5) v5(53.6,44.31) v5(53.66,1.01) v5(54.07,34.5) v5(55.14,32.16) v5(55.82,61.05) v5(55.9,32.16) v5(56.66,1.01) v5(57.78,46.58) v5(58.36,61.05) v5(58.69,53.98) v5(59.15,53.4) v5(59.2,1.01) v5(59.92,46.47) v5(60.45,61.05) v5(60.66,46.47) v5(60.66,45.73) v5(61.4,46.47) v5(61.74,1.01) v5(61.98,40.92) v5(61.98,40.18) v5(62.13,46.47) v5(62.13,45.73) v5(62.72,40.92) v5(62.72,40.18) v5(63.46,40.92) v5(63.46,40.18) v5(64.28,1.01) v5(65.98,61.05) v5(67.43,0.9) v5(68.32,2.78) v5(68.52,61.05) v5(68.63,23.87) v5(69.21,4.17) v5(70.33,9.38) v5(70.35,10.5) v5(70.38,7.86) v5(70.86,9.91) v5(71.06,61.05) v5(71.22,10.57) v5(71.62,9.94) v5(72.03,10.57) v5(72.26,17.19) v5(72.26,16.45) v5(72.41,9.94) v5(73.6,61.05) v5(73.68,24.58) v5(73.68,23.84) v5(74.42,24.58) v5(74.42,23.84) v5(75.15,24.58) v5(75.15,23.84) v5(76.04,53.15) v5(76.04,52.42) v5(76.14,61.05) v5(76.76,12.01) v5(77.11,36.24) v5(77.51,11.97) v5(77.64,43.58) v5(77.85,36.18) v5(78.18,44.67) v5(78.3,43.93) v5(78.68,61.05) v5(78.99,44.69) v5(79.04,43.96) v5(80.06,51.7) v5(80.74,57.11) v5(80.74,56.35) v5(80.77,57.88) v5(80.89,51.7) v5(81.22,61.05) v5(81.76,51.7) v5(83.76,61.05) v5(84.88,51.7) v5(86.3,61.05) v5(87.6,18.05) v5(87.62,7.98) v5(87.75,15) v5(87.85,16.42) v5(87.85,13.58) v5(88.84,61.05) v5(91.18,3.01) v5(91.38,61.05) v5(93.72,3.01) v5(93.92,61.05) v5(95.85,20.64) v5(95.85,19.9) v5(95.85,19.17) v5(96.26,3.01) v5(96.46,61.05) v5(98.8,3.01) v5(99,61.05) v5(100.83,32.82) v5(101.34,3.01) v5(101.54,61.05) v5(101.69,32.8) v5(103.88,3.01) v5(104.08,61.05) v5(106.62,61.05) v5(109.16,61.05) v5(111.37,61.12) v5(121.86,61.05) v5(124.4,61.05) v5(126.94,61.05) v5(129.48,61.05) v5(129.53,3.01) v5(129.53,1.11) v5(132.02,61.05) v5(132.07,1.11) v5(134.56,61.05) v5(134.61,1.11) v5(137.1,61.05) v5(137.15,1.11) v5(139.64,61.05) v5(140.15,0.83) v5(142.18,61.05) v5(144.72,61.05) v5(147.26,61.05) v5(149.8,61.05) v5(149.85,0.83) v5(152.34,61.05) v5(152.39,0.83) v5(154.53,55.08) v5(154.53,53.61) v5(154.88,61.05) v5(154.93,0.83) v5(157.42,61.05) v5(157.42,52.06) v5(157.47,0.83) v5(158.16,52.06) v5(158.9,52.06) v5(159.63,52.06) v5(159.96,61.05) v5(160.01,0.83) v5(160.38,23.93) v5(162.5,61.05) v5(162.55,0.83) v5(162.83,31.32) v5(163.19,47.25) v5(163.19,45.8) v5(163.85,49.23) v5(165.04,61.05) v5(165.09,0.83) v5(167.63,0.83) v5(170.17,0.83) v5(172.66,61.05) v5(172.71,0.83) v5(175.25,0.83) v5(177.03,40.12) v5(177.03,39.39) v5(177.03,38.65) v5(177.03,37.91) v5(177.03,37.18) v5(177.03,36.44) v5(177.03,35.7) v5(177.03,34.97) v5(177.03,34.23) v5(177.49,31) v5(177.77,40.12) v5(177.77,39.39) v5(177.77,38.65) v5(177.77,37.91) v5(177.77,37.18) v5(177.77,36.44) v5(177.77,35.7) v5(177.77,34.97) v5(177.77,34.23) v5(177.79,0.83) v5(178.43,58.15) v5(178.51,40.12) v5(178.51,39.39) v5(178.51,38.65) v5(178.51,37.91) v5(178.51,37.18) v5(178.51,36.44) v5(178.51,35.7) v5(178.51,34.97) v5(178.51,34.23) v5(178.71,30.93) v5(179.24,40.12) v5(179.24,39.39) v5(179.24,38.65) v5(179.24,37.91) v5(179.24,37.18) v5(179.24,36.44) v5(179.24,35.7) v5(179.24,34.97) v5(179.24,34.23) v5(179.98,40.12) v5(179.98,39.39) v5(179.98,38.65) v5(179.98,37.91) v5(179.98,37.18) v5(179.98,36.44) v5(179.98,35.7) v5(179.98,34.97) v5(179.98,34.23) v5(180.33,0.83) v5(180.97,58.15) v5(182.87,0.83) v5(183.64,58.15) v5(185.41,0.83) v5(187.95,0.83) v5(190.24,58.78) v5(190.49,0.83) v5(191.76,58.15) v5(193.03,0.83) v5(193.92,58.15) v5(195.57,0.83) v5(196.08,58.15) v5(197.61,58.91) v5(201.14,59.54) v5(201.11,58.25) v5(205.73,1.11) v5(208.3,29.78) v5(208.27,1.11) v5(210.84,29.78) v5(210.81,1.11) v5(213.38,29.78) v5(213.35,1.11) v5(215.92,29.78) v5(215.89,1.11) v5(216.78,2.65) v5(218.46,29.78) v5(218.69,1) v5(221,29.78) v5(223.54,29.78) v5(226.08,29.78) v5(228.62,29.78) v5(231.16,29.78) v5(232.43,1.05) v5(233.7,29.78) v5(235.58,1.02) v5(236.24,29.78) v5(238.78,29.78) v5(240.3,1) v5(242.41,1.01) v5(243.86,29.78) v5(244.95,1.01) v5(245.97,29.86) v5(247.49,1.01) v5(247.92,35.14) v5(247.9,33.03) v5(247.92,29.95) v5(248.1,36.86) v5(250.03,1.01) v5(252.52,37.12) v5(252.57,1.01) v5(254.12,37.07) v5(255.11,1.01) v5(258.34,1.02) v5(260.19,1.01) v5(262.73,1.01) v6(235.58,26.32) v6(236.39,24.09) v6(237.79,24.9) v6(237.92,26.02) v6(237.86,22.77) v6(242.8,23.31) v6(244.09,24.04) v6(244.57,23.38) v6(259.05,36.38) v6(259.56,32.21) v6(259.71,28.56) v6(260.34,34.27) v6(260.34,30.79) v6(260.37,27.31) v6(260.67,29.88) v6(260.9,26.8) v7(45.26,17.05) v7(52.19,33.18) v7(52.17,32.19) v7(52.37,32.98) v7(52.37,32.01) v7(58.8,7.07) v7(58.93,12.58) v7(64.15,26.68) v7(69.24,25.82) v7(69.85,47.09) v7(72,19.27) v7(72.97,19.37) v7(77.13,32.4) v7(89.53,26.78) v7(89.91,27.03) v7(89.91,26.65) v7(90.46,28.91) v7(94.56,28.66) v7(97.05,28.56) v7(100.73,48.1) v7(100.73,47.74) v7(100.99,48.1) v7(100.99,47.74) v7(101.14,28.16) v7(102.05,9.28) v7(102.61,40.67) v7(103.17,9.18) v7(103.75,40.66) v7(104.34,45.75) v7(104.64,45.75) v7(104.69,49.44) v7(104.69,8.87) v7(104.77,50.07) v7(105.35,27.38) v7(105.76,45.73) v7(106.12,9.18) v7(106.19,45.7) v7(106.37,27.38) v7(107,45.38) v7(107,41.59) v7(107.54,9.28) v7(108.52,41.02) v7(109.31,33.03) v7(109.52,22.49) v7(110.41,48.42) v7(110.41,47.81) v7(110.69,50.32) v7(110.81,46.75) v7(110.82,22.49) v7(110.89,48.17) v7(110.95,39.22) v7(110.89,9.18) v7(110.97,47.84) v7(111.09,50.73) v7(111.09,50.32) v7(111.4,50.73) v7(111.5,50.32) v7(111.5,46.79) v7(111.7,9.08) v7(111.91,50.32) v7(112.41,43.87) v7(112.85,46.51) v7(112.85,46.26) v7(112.85,35.02) v7(112.92,55.3) v7(113.02,56.22) v7(113.02,55.71) v7(113.43,56.22) v7(113.43,55.71) v7(113.43,55.3) v7(113.68,41.26) v7(113.68,40.39) v7(113.84,56.22) v7(113.79,55.23) v7(114.15,42.9) v7(114.16,59.16) v7(114.65,33.64) v7(115.11,43.34) v7(115.13,37.72) v7(115.26,44.62) v7(115.31,32.65) v7(115.51,43.39) v7(115.46,42.35) v7(115.64,45.27) v7(115.72,44.79) v7(115.72,44.53) v7(115.72,44.28) v7(115.72,44.03) v7(115.72,43.77) v7(115.74,43.52) v7(115.66,37.72) v7(115.85,42.65) v7(115.77,39.83) v7(115.93,42.29) v7(115.92,42.02) v7(116,43.16) v7(115.97,39.45) v7(116.15,39.66) v7(116.48,46.64) v7(116.48,39.66) v7(116.63,49.34) v7(117.19,8.87) v7(117.42,32.04) v7(117.65,41.54) v7(117.62,40.94) v7(117.62,40.38) v7(117.59,39.74) v7(117.67,42.25) v7(118,43.14) v7(118.03,41.52) v7(118.03,40.37) v7(118.04,39.78) v7(118.05,47.94) v7(118.08,45.22) v7(118.08,44.94) v7(118.08,44.23) v7(118.1,43.85) v7(118.08,42.45) v7(118.08,42.2) v7(118.07,40.93) v7(118.15,46.36) v7(118.15,43.49) v7(118.82,9.18) v7(119.64,45.41) v7(119.65,46.06) v7(119.69,44.81) v7(119.69,44.28) v7(119.68,43.72) v7(119.68,43.11) v7(119.66,42.38) v7(119.66,42.1) v7(119.65,41.5) v7(119.65,41.19) v7(119.67,40.93) v7(119.67,40.62) v7(119.66,40.36) v7(119.83,9.38) v7(120.03,32.65) v7(120.73,45.29) v7(120.7,44.85) v7(120.73,44.14) v7(120.79,47.66) v7(120.82,46.11) v7(120.75,43.76) v7(120.79,42.81) v7(120.77,41.54) v7(120.79,22.49) v7(120.87,34.2) v7(121.08,46.33) v7(121.13,43.73) v7(121.15,40.37) v7(121.05,9.28) v7(121.2,45.91) v7(121.16,44.81) v7(121.18,42.57) v7(121.17,41.45) v7(121.16,39.25) v7(121.41,46.28) v7(121.44,16.09) v7(121.64,45.91) v7(121.64,43.72) v7(121.64,42.6) v7(121.65,44.8) v7(121.71,41.48) v7(121.67,40.37) v7(121.68,39.26) v7(121.76,47.73) v7(121.87,46.28) v7(122.09,43.76) v7(122.12,41.5) v7(122.15,40.39) v7(122.09,22.49) v7(122.09,16.09) v7(122.15,46) v7(122.2,42.66) v7(122.17,34.52) v7(122.17,9.18) v7(122.25,39.25) v7(122.43,46.28) v7(122.63,45.91) v7(122.62,42.65) v7(122.67,44.81) v7(122.71,43.73) v7(122.75,41.54) v7(122.68,32.7) v7(122.8,39.35) v7(122.85,47.61) v7(122.86,46.28) v7(122.85,40.44) v7(123.11,43.74) v7(123.14,42.66) v7(123.13,40.39) v7(123.15,39.21) v7(123.21,46.33) v7(123.15,46) v7(123.16,41.51) v7(123.29,9.38) v7(123.49,32.7) v7(123.72,46.15) v7(123.72,44.76) v7(123.72,43.66) v7(123.71,42.61) v7(123.67,41.53) v7(123.72,39.2) v7(123.77,47.73) v7(123.9,36.91) v7(124.06,36.3) v7(124.41,46.15) v7(124.4,9.38) v7(124.94,36.86) v7(125.39,33.57) v7(125.42,9.48) v7(125.62,41.28) v7(125.62,40.98) v7(125.6,37.73) v7(125.93,41.28) v7(125.95,40.98) v7(126.44,37.73) v7(126.66,31.99) v7(127.18,45.62) v7(127.18,45.34) v7(127.25,37.73) v7(127.3,44.73) v7(127.48,45.34) v7(127.74,45.34) v7(127.86,33.41) v7(128.01,45.34) v7(128.11,44.73) v7(128.29,45.37) v7(128.8,45.14) v7(128.77,44.84) v7(129.15,45.12) v7(129.18,44.84) v7(129.58,37.02) v7(129.58,36.71) v7(129.89,37.02) v7(129.89,36.71) v7(130.19,37.02) v7(130.19,36.71) v7(130.5,37.02) v7(130.5,36.71) v7(130.8,37.02) v7(130.8,36.71) v7(131.11,37.02) v7(131.11,36.71) v7(131.41,37.02) v7(131.41,36.71) v7(131.72,37.02) v7(131.72,36.71) v7(132.02,37.02) v7(132.02,36.71) v7(132.33,37.02) v7(132.33,36.71) v7(133.65,20.96) v7(133.65,19.64) v7(133.65,18.32) v7(133.65,16.9) v7(133.65,15.48) v7(133.75,22.38) v7(134.87,18.12) v7(134.87,14.56) v7(134.97,22.18) v7(134.99,9.01) v7(134.99,6.32) v7(136.01,6.24) v7(136.14,9.09) v7(137.05,11.93) v7(137.05,9.24) v7(137.93,19.45) v7(138.01,33.54) v7(138.15,20.51) v7(138.07,12.02) v7(138.07,9.16) v7(138.4,32.45) v7(138.45,34.58) v7(138.85,40.73) v7(139.59,5.67) v7(139.59,5.37) v7(141.6,8.16) v7(141.6,7.91) v7(142.28,10.29) v7(142.49,11.19) v7(143,41.51) v7(143,40.21) v7(143,38.91) v7(143,36.96) v7(143,35.01) v7(143,33.71) v7(143,32.41) v7(143,22.88) v7(143,21.58) v7(143,19.63) v7(143.38,11.19) v7(144.11,5.67) v7(144.11,5.37) v7(144.38,11.28) v7(144.6,37.61) v7(144.6,20.28) v7(145.4,38.26) v7(145.4,20.93) v7(146.2,38.26) v7(146.2,22.88) v7(146.2,20.93) v7(150.56,4.29) v7(151.56,6.79) v7(151.56,6.29) v7(151.96,11.31) v7(154.17,58.15) v7(154.17,57.84) v7(154.17,57.54) v7(154.17,57.23) v7(154.17,56.93) v7(154.48,58.15) v7(154.48,57.84) v7(154.48,57.54) v7(154.48,57.23) v7(154.48,56.93) v7(154.48,11.31) v7(155.09,12.43) v7(155.44,11.31) v7(156.2,36.41) v7(156.2,34.98) v7(156.51,34.98) v7(156.61,40.8) v7(156.61,39.76) v7(156.61,36.41) v7(156.71,38.74) v7(156.71,37.73) v7(156.71,19.34) v7(156.71,18.83) v7(156.71,18.42) v7(156.92,41.18) v7(156.92,40.67) v7(156.92,40.16) v7(156.92,34.98) v7(157.02,36.41) v7(157.12,39.76) v7(157.12,19.34) v7(157.12,18.83) v7(157.12,18.42) v7(157.32,34.98) v7(157.32,33.56) v7(157.3,11.31) v7(157.42,31.33) v7(157.42,30.51) v7(157.42,28.48) v7(157.52,19.34) v7(157.52,18.83) v7(157.52,18.42) v7(157.7,9.13) v7(157.96,12.43) v7(157.98,9.13) v7(159.76,21.44) v7(160.45,12.48) v7(160.45,8.24) v7(160.45,7.96) v7(163.8,14.84) v7(164.56,13.57) v7(164.66,14.94) v7(165.98,13.29) v7(165.98,12.48) v7(166.62,14.99) v7(166.62,14.16) v7(166.62,13.29) v7(168.6,12.07) v7(169.11,50.93) v7(169.41,50.53) v7(169.51,50.93) v7(169.46,9.68) v7(169.72,50.22) v7(169.82,50.53) v7(170.02,49.92) v7(170.12,50.22) v7(170.27,25.06) v7(170.43,49.92) v7(170.43,49.11) v7(170.43,48.6) v7(170.94,49.51) v7(170.94,49.11) v7(170.94,48.7) v7(171.44,49.72) v7(171.6,13.57) v7(171.9,50.09) v7(171.9,48.82) v7(171.85,13.75) v7(171.95,49.72) v7(172.05,6) v7(172.36,49.72) v7(172.66,50.09) v7(172.66,48.82) v7(172.78,13.85) v7(173.17,49.61) v7(173.43,50.09) v7(173.43,48.82) v7(173.78,49.61) v7(174.11,8.08) v7(174.19,50.09) v7(174.19,48.82) v7(174.54,5.42) v7(174.59,49.61) v7(174.95,50.09) v7(174.95,48.82) v7(175.89,2.69) v7(179.16,2.78) v7(179.41,10.27) v7(179.57,7.72) v7(179.92,10.27) v7(180.08,14.22) v7(180.53,13.19) v7(180.59,2.78) v7(181.1,2.78) v7(181.98,14.21) v7(182.42,48.29) v7(182.82,48.29) v7(183.23,48.29) v7(183.79,8.62) v7(184.14,9.71) v7(184.45,48.29) v7(184.4,2.78) v7(184.86,48.29) v7(184.91,2.78) v7(185.26,48.29) v7(186.07,48.29) v7(186.48,48.29) v7(186.89,48.29) v7(186.94,11.03) v7(186.94,10.14) v7(186.94,9.25) v7(188.21,2.67) v7(188.31,5.19) v7(188.49,2.9) v7(188.82,2.75) v7(189.15,2.98) v7(189.7,9.89) v7(190.27,14.84) v7(191.76,33.77) v7(191.89,24.75) v7(192.78,33.77) v7(192.78,29.73) v7(192.92,2.65) v7(193.77,28.56) v7(194.91,28.56) v7(194.94,5.56) v7(195.16,4.68) v7(195.16,3.16) v7(195.95,3.78) v7(197.22,22.71) v7(198.5,3.41) v7(198.7,51.37) v7(198.7,51.06) v7(198.75,31.47) v7(198.75,30.34) v7(198.65,13.57) v7(199.64,30.31) v7(199.55,16) v7(200.03,17.25) v7(200.65,2.64) v7(201.54,33.76) v7(201.67,37.42) v7(201.79,3.66) v7(201.93,18.27) v7(201.92,9.28) v7(202.05,33.76) v7(202.43,20.82) v7(203.07,13.09) v7(203.32,23.99) v7(203.32,22.98) v7(203.96,20.82) v7(204.97,17.69) v7(204.97,13.57) v7(204.97,9.76) v7(205.48,17.38) v7(205.48,13.57) v7(205.48,9.76) v7(206.27,4.17) v7(206.5,12.27) v7(206.78,4.17) v7(207.64,12.84) v7(208.15,12.84) v7(210.56,22.22) v7(210.81,21.96) v7(212.59,18.39) v7(212.94,17.27) v7(213.58,14.97) v7(214.89,7.09) v7(214.98,18.14) v7(215.92,12.79) v7(216.4,19.8) v7(217.42,19.8) v7(217.64,14.21) v7(217.64,13.44) v7(218.18,28.31) v7(218.43,15.73) v7(218.41,10.17) v7(218.92,10.17) v7(219.11,25.16) v7(219.2,28.31) v7(220.21,28.31) v7(221.23,28.31) v7(221.47,13.48) v7(221.57,8.1) v7(222.88,15.09) v7(223.26,28.31) v7(229.94,22.99) v7(233.6,10.45) v7(233.72,10.68) v7(234.17,12.05) v7(234.56,17.63) v7(234.79,10.04) v7(235.07,17.63) v7(235.07,10.04) v7(235.58,26.32) v7(235.58,21.83) v7(236.39,24.09) v7(237.49,15.73) v7(237.49,14.59) v7(237.79,24.9) v7(237.92,26.02) v7(237.86,22.77) v7(240.53,22.02) v7(242.8,23.31) v7(243.86,15.81) v7(244.09,24.04) v7(244.57,23.38) v7(247.24,28.07) v7(248.1,27.99) v7(250.57,27.22) v7(255.01,25.89) v7(255.04,22.59) v7(255.17,19.67) v7(255.4,28.18) v7(256.03,16.48) v7(256.42,18.27) v7(257.42,33.26) v7(257.42,30.71) v7(259.05,36.38) v7(258.98,34.27) v7(259.56,32.21) v7(259.71,28.56) v7(260.34,34.27) v7(260.34,30.79) v7(260.37,27.31) v7(260.67,29.88) v7(260.9,26.8) v7(261.39,30.84) v8(45.26,17.05) v8(52.19,33.18) v8(52.17,32.19) v8(52.37,32.98) v8(52.37,32.01) v8(58.8,7.07) v8(58.93,12.58) v8(64.15,26.68) v8(69.24,25.82) v8(69.85,47.09) v8(72,19.27) v8(72.97,19.37) v8(77.13,32.4) v8(89.53,26.78) v8(89.91,27.03) v8(89.91,26.65) v8(90.46,28.91) v8(94.56,28.66) v8(97.05,28.56) v8(100.73,48.1) v8(100.73,47.74) v8(100.99,48.1) v8(100.99,47.74) v8(101.14,28.16) v8(102.05,9.28) v8(102.61,40.67) v8(103.17,9.18) v8(103.75,40.66) v8(104.34,45.75) v8(104.64,45.75) v8(104.69,49.44) v8(104.69,8.87) v8(104.77,50.07) v8(105.35,27.38) v8(105.76,45.73) v8(106.12,9.18) v8(106.19,45.7) v8(106.37,27.38) v8(107,45.38) v8(107,41.59) v8(107.54,9.28) v8(108.52,41.02) v8(109.31,33.03) v8(109.52,22.49) v8(110.41,48.42) v8(110.41,47.81) v8(110.69,50.32) v8(110.81,46.75) v8(110.82,22.49) v8(110.89,48.17) v8(110.95,39.22) v8(110.89,9.18) v8(110.97,47.84) v8(111.09,50.73) v8(111.09,50.32) v8(111.4,50.73) v8(111.5,50.32) v8(111.5,46.79) v8(111.7,9.08) v8(111.91,50.32) v8(112.41,43.87) v8(112.85,46.51) v8(112.85,46.26) v8(112.85,35.02) v8(112.92,55.3) v8(113.02,56.22) v8(113.02,55.71) v8(113.43,56.22) v8(113.43,55.71) v8(113.43,55.3) v8(113.68,41.26) v8(113.68,40.39) v8(113.84,56.22) v8(113.79,55.23) v8(114.15,42.9) v8(114.16,59.16) v8(114.65,33.64) v8(115.11,43.34) v8(115.13,37.72) v8(115.26,44.62) v8(115.31,32.65) v8(115.51,43.39) v8(115.46,42.35) v8(115.64,45.27) v8(115.72,44.79) v8(115.72,44.53) v8(115.72,44.28) v8(115.72,44.03) v8(115.72,43.77) v8(115.74,43.52) v8(115.66,37.72) v8(115.85,42.65) v8(115.77,39.83) v8(115.93,42.29) v8(115.92,42.02) v8(116,43.16) v8(115.97,39.45) v8(116.15,39.66) v8(116.48,46.64) v8(116.48,39.66) v8(116.63,49.34) v8(117.19,8.87) v8(117.42,32.04) v8(117.65,41.54) v8(117.62,40.94) v8(117.62,40.38) v8(117.59,39.74) v8(117.67,42.25) v8(118,43.14) v8(118.03,41.52) v8(118.03,40.37) v8(118.04,39.78) v8(118.05,47.94) v8(118.08,45.22) v8(118.08,44.94) v8(118.08,44.23) v8(118.1,43.85) v8(118.08,42.45) v8(118.08,42.2) v8(118.07,40.93) v8(118.15,46.36) v8(118.15,43.49) v8(118.82,9.18) v8(119.64,45.41) v8(119.65,46.06) v8(119.69,44.81) v8(119.69,44.28) v8(119.68,43.72) v8(119.68,43.11) v8(119.66,42.38) v8(119.66,42.1) v8(119.65,41.5) v8(119.65,41.19) v8(119.67,40.93) v8(119.67,40.62) v8(119.66,40.36) v8(119.83,9.38) v8(120.03,32.65) v8(120.73,45.29) v8(120.7,44.85) v8(120.73,44.14) v8(120.79,47.66) v8(120.79,22.49) v8(120.87,34.2) v8(121.08,46.33) v8(121.13,43.73) v8(121.15,40.37) v8(121.05,9.28) v8(121.2,45.91) v8(121.16,44.81) v8(121.18,42.57) v8(121.17,41.45) v8(121.16,39.25) v8(121.41,46.28) v8(121.44,16.09) v8(121.64,45.91) v8(121.64,43.72) v8(121.64,42.6) v8(121.65,44.8) v8(121.71,41.48) v8(121.67,40.37) v8(121.68,39.26) v8(121.76,47.73) v8(121.87,46.28) v8(122.09,22.49) v8(122.09,16.09) v8(122.17,34.52) v8(122.17,9.18) v8(122.43,46.28) v8(122.63,45.91) v8(122.67,44.81) v8(122.71,43.73) v8(122.75,41.54) v8(122.68,32.7) v8(122.8,39.35) v8(122.85,47.61) v8(122.86,46.28) v8(122.85,40.44) v8(123.15,39.21) v8(123.21,46.33) v8(123.16,41.51) v8(123.29,9.38) v8(123.49,32.7) v8(123.72,46.15) v8(123.72,44.76) v8(123.72,43.66) v8(123.67,41.53) v8(123.77,47.73) v8(123.9,36.91) v8(124.06,36.3) v8(124.41,46.15) v8(124.4,9.38) v8(124.94,36.86) v8(125.39,33.57) v8(125.42,9.48) v8(125.62,41.28) v8(125.62,40.98) v8(125.6,37.73) v8(125.93,41.28) v8(125.95,40.98) v8(126.44,37.73) v8(126.66,31.99) v8(127.18,45.62) v8(127.18,45.34) v8(127.25,37.73) v8(127.3,44.73) v8(127.48,45.34) v8(127.74,45.34) v8(127.86,33.41) v8(128.01,45.34) v8(128.11,44.73) v8(128.29,45.37) v8(128.8,45.14) v8(128.77,44.84) v8(129.15,45.12) v8(129.18,44.84) v8(129.58,37.02) v8(129.58,36.71) v8(129.89,37.02) v8(129.89,36.71) v8(130.19,37.02) v8(130.19,36.71) v8(130.5,37.02) v8(130.5,36.71) v8(130.8,37.02) v8(130.8,36.71) v8(131.11,37.02) v8(131.11,36.71) v8(131.41,37.02) v8(131.41,36.71) v8(131.72,37.02) v8(131.72,36.71) v8(132.02,37.02) v8(132.02,36.71) v8(132.33,37.02) v8(132.33,36.71) v8(133.65,20.96) v8(133.65,19.64) v8(133.65,18.32) v8(133.65,16.9) v8(133.65,15.48) v8(133.75,22.38) v8(134.87,18.12) v8(134.87,14.56) v8(134.97,22.18) v8(134.99,9.01) v8(134.99,6.32) v8(136.01,6.24) v8(136.14,9.09) v8(137.05,11.93) v8(137.05,9.24) v8(137.93,19.45) v8(138.01,33.54) v8(138.15,20.51) v8(138.07,12.02) v8(138.07,9.16) v8(138.4,32.45) v8(138.45,34.58) v8(138.85,40.73) v8(139.59,5.67) v8(139.59,5.37) v8(141.6,8.16) v8(141.6,7.91) v8(142.28,10.29) v8(142.49,11.19) v8(143,41.51) v8(143,40.21) v8(143,38.91) v8(143,36.96) v8(143,35.01) v8(143,33.71) v8(143,32.41) v8(143,22.88) v8(143,21.58) v8(143,19.63) v8(143.38,11.19) v8(144.11,5.67) v8(144.11,5.37) v8(144.38,11.28) v8(144.6,37.61) v8(144.6,20.28) v8(145.4,38.26) v8(145.4,20.93) v8(146.2,38.26) v8(146.2,22.88) v8(146.2,20.93) v8(150.56,4.29) v8(151.56,6.79) v8(151.56,6.29) v8(151.96,11.31) v8(154.17,58.15) v8(154.17,57.84) v8(154.17,57.54) v8(154.17,57.23) v8(154.17,56.93) v8(154.48,58.15) v8(154.48,57.84) v8(154.48,57.54) v8(154.48,57.23) v8(154.48,56.93) v8(154.48,11.31) v8(155.09,12.43) v8(155.44,11.31) v8(156.2,36.41) v8(156.2,34.98) v8(156.51,34.98) v8(156.61,40.8) v8(156.61,39.76) v8(156.61,36.41) v8(156.71,38.74) v8(156.71,37.73) v8(156.71,19.34) v8(156.71,18.83) v8(156.71,18.42) v8(156.92,41.18) v8(156.92,40.67) v8(156.92,40.16) v8(156.92,34.98) v8(157.02,36.41) v8(157.12,39.76) v8(157.12,19.34) v8(157.12,18.83) v8(157.12,18.42) v8(157.32,34.98) v8(157.32,33.56) v8(157.3,11.31) v8(157.42,31.33) v8(157.42,30.51) v8(157.42,28.48) v8(157.52,19.34) v8(157.52,18.83) v8(157.52,18.42) v8(157.7,9.13) v8(157.96,12.43) v8(157.98,9.13) v8(159.76,21.44) v8(160.45,12.48) v8(160.45,8.24) v8(160.45,7.96) v8(163.8,14.84) v8(164.56,13.57) v8(164.66,14.94) v8(165.98,13.29) v8(165.98,12.48) v8(166.62,14.99) v8(166.62,14.16) v8(166.62,13.29) v8(168.6,12.07) v8(169.11,50.93) v8(169.41,50.53) v8(169.51,50.93) v8(169.46,9.68) v8(169.72,50.22) v8(169.82,50.53) v8(170.02,49.92) v8(170.12,50.22) v8(170.27,25.06) v8(170.43,49.92) v8(170.43,49.11) v8(170.43,48.6) v8(170.94,49.51) v8(170.94,49.11) v8(170.94,48.7) v8(171.44,49.72) v8(171.6,13.57) v8(171.9,50.09) v8(171.9,48.82) v8(171.85,13.75) v8(171.95,49.72) v8(172.05,6) v8(172.36,49.72) v8(172.66,50.09) v8(172.66,48.82) v8(172.78,13.85) v8(173.17,49.61) v8(173.43,50.09) v8(173.43,48.82) v8(173.78,49.61) v8(174.11,8.08) v8(174.19,50.09) v8(174.19,48.82) v8(174.54,5.42) v8(174.59,49.61) v8(174.95,50.09) v8(174.95,48.82) v8(175.89,2.69) v8(179.16,2.78) v8(179.41,10.27) v8(179.57,7.72) v8(179.92,10.27) v8(180.08,14.22) v8(180.53,13.19) v8(180.59,2.78) v8(181.1,2.78) v8(181.98,14.21) v8(182.42,48.29) v8(182.82,48.29) v8(183.23,48.29) v8(183.79,8.62) v8(184.14,9.71) v8(184.45,48.29) v8(184.4,2.78) v8(184.86,48.29) v8(184.91,2.78) v8(185.26,48.29) v8(186.07,48.29) v8(186.48,48.29) v8(186.89,48.29) v8(186.94,11.03) v8(186.94,10.14) v8(186.94,9.25) v8(188.21,2.67) v8(188.31,5.19) v8(188.82,2.75) v8(189.7,9.89) v8(190.27,14.84) v8(191.76,33.77) v8(191.89,24.75) v8(192.78,33.77) v8(192.78,29.73) v8(192.92,2.65) v8(193.77,28.56) v8(194.91,28.56) v8(194.94,5.56) v8(195.16,4.68) v8(195.16,3.16) v8(195.95,3.78) v8(197.22,22.71) v8(198.5,3.41) v8(198.7,51.37) v8(198.7,51.06) v8(198.75,31.47) v8(198.75,30.34) v8(198.65,13.57) v8(199.64,30.31) v8(199.55,16) v8(200.03,17.25) v8(200.65,2.64) v8(201.54,33.76) v8(201.67,37.42) v8(201.79,3.66) v8(201.93,18.27) v8(201.92,9.28) v8(202.05,33.76) v8(202.43,20.82) v8(203.07,13.09) v8(203.32,23.99) v8(203.32,22.98) v8(203.96,20.82) v8(204.97,17.69) v8(204.97,13.57) v8(204.97,9.76) v8(205.48,17.38) v8(205.48,13.57) v8(205.48,9.76) v8(206.27,4.17) v8(206.5,12.27) v8(206.78,4.17) v8(207.64,12.84) v8(208.15,12.84) v8(210.56,22.22) v8(210.81,21.96) v8(212.59,18.39) v8(212.94,17.27) v8(213.58,14.97) v8(214.89,7.09) v8(214.98,18.14) v8(215.92,12.79) v8(216.4,19.8) v8(217.42,19.8) v8(217.64,14.21) v8(217.64,13.44) v8(218.18,28.31) v8(218.43,15.73) v8(218.41,10.17) v8(218.92,10.17) v8(219.11,25.16) v8(219.2,28.31) v8(220.21,28.31) v8(221.23,28.31) v8(221.47,13.48) v8(221.57,8.1) v8(222.88,15.09) v8(223.26,28.31) v8(229.94,22.99) v8(233.6,10.45) v8(233.72,10.68) v8(234.17,12.05) v8(234.56,17.63) v8(234.79,10.04) v8(235.07,17.63) v8(235.07,10.04) v8(235.58,26.32) v8(235.58,21.83) v8(236.39,24.09) v8(237.49,15.73) v8(237.49,14.59) v8(237.79,24.9) v8(237.92,26.02) v8(237.86,22.77) v8(240.53,22.02) v8(242.8,23.31) v8(243.86,15.81) v8(244.09,24.04) v8(244.57,23.38) v8(247.24,28.07) v8(248.1,27.99) v8(250.57,27.22) v8(255.01,25.89) v8(255.04,22.59) v8(255.17,19.67) v8(255.4,28.18) v8(256.03,16.48) v8(256.42,18.27) v8(257.42,33.26) v8(257.42,30.71) v8(259.05,36.38) v8(258.98,34.27) v8(259.56,32.21) v8(259.71,28.56) v8(260.34,34.27) v8(260.34,30.79) v8(260.31,28.56) v8(260.37,27.31) v8(260.67,29.88) v8(260.9,26.8) v8(261.39,30.84) v9(65.8,43.6) v9(68.76,45.48) v9(68.75,44.97) v9(69.26,45.99) v9(69.26,45.48) v9(69.26,44.97) v9(69.77,45.96) v9(69.77,45.48) v9(69.77,44.97) v9(72.08,46.65) v9(72.59,45.56) v9(72.76,43.4) v9(73.2,43.27) v9(74.42,45.99) v9(98.34,48.67) v9(98.98,48.78) v9(99.28,42.43) v9(100.58,47.23) v9(101.14,47.28) v9(104.34,42.53) v9(104.49,45.45) v9(104.98,40.8) v9(105.2,49.74) v9(105.96,45.4) v9(106.39,45.4) v9(106.95,32.72) v9(108.14,46.56) v9(108.88,45.35) v9(109.07,49.85) v9(109.19,43.11) v9(109.37,45.37) v9(110.03,47.72) v9(111.05,49.15) v9(111.09,37.19) v9(112.03,40.04) v9(112.46,48.57) v9(114.34,48.62) v9(115.54,40.09) v9(115.56,41.81) v9(115.56,41.2) v9(115.56,40.64) v9(115.59,39.54) v9(117.29,37.31) v9(117.82,40.65) v9(117.84,40.05) v9(117.88,41.21) v9(119.53,50.88) v9(119.5,45.09) v9(119.5,44) v9(119.5,43.42) v9(120.14,34.22) v9(120.19,48.66) v9(120.82,39.38) v9(121.25,47.84) v9(121.43,41.66) v9(121.91,44.56) v9(121.89,43.47) v9(121.91,41.21) v9(121.91,40.11) v9(121.94,39.02) v9(121.91,35.44) v9(122.42,41.66) v9(122.9,44.56) v9(122.9,43.44) v9(122.88,40.09) v9(122.88,39) v9(124.05,48.09) v9(124.28,38.31) v9(125.14,42.43) v9(125.65,42.4) v9(126,38.18) v9(126.03,33.64) v9(126.16,42.43) v9(126.49,38.18) v9(127.35,41.69) v9(127.4,40.77) v9(127.6,45.68) v9(127.96,40.77) v9(128.14,45.68) v9(128.57,45.68) v9(138.09,34.7) v9(138.21,33.01) v9(142.87,34.53) v9(142.97,39.48) v9(143.4,42.6) v9(143.38,35.24) v9(143.68,35.82) v9(144.62,39.58) v9(145.03,41.26) v9(145,33.54) v9(144.95,31.55) v9(145.1,38.72) v9(146.15,38.87) v9(146.55,40.65) v9(229.86,26.02) v9(231.01,25) v9(231.77,26.65) v9(234.28,23.86) v9(245.74,25.89) v9(267.05,18.24) v10(188.49,2.9) v10(189.15,2.98) v11(108.99,45.75) v11(109.05,42.49) v11(110.04,42.49) v11(114.65,46.41) v11(114.72,45.95) v11(114.72,45.4) v11(114.72,44.28) v11(114.76,44.83) v11(116.96,35.07) v11(118.99,34.02) v11(118.99,33.74) v11(119.21,36.8) v11(119.21,35.32) v11(119.81,48.94) v11(121.51,33.66) v11(121.51,33.38) v11(122.11,37.04) v11(122.11,36.55) v11(123.72,37.29) v11(124.04,37.53) v11(124.17,38.63) v11(124.42,38.31) v11(124.36,37.29) v11(124.67,38.63) v11(125.16,38.63) v11(125.41,37.66) v11(125.65,37.34) v11(125.65,35.81) v11(125.76,36.21) v11(126,33.99) v11(126.26,33.92) v11(126.48,35.6) v11(126.64,36.7) v11(126.64,36.05) v12(108.99,45.75) v12(109.05,42.49) v12(116.96,35.07) v12(118.99,34.02) v12(118.99,33.74) v12(119.21,36.8) v12(119.21,35.32) v12(119.81,48.94) v12(121.51,33.66) v12(121.51,33.38) v12(122.11,36.55) v12(123.72,37.29) v12(124.04,37.53) v12(124.17,38.63) v12(124.67,38.63) v12(125.16,38.63) v12(125.41,37.66) v12(125.65,37.34) v12(125.65,35.81) v12(125.76,36.21) v12(126,33.99) v12(126.26,33.92) v12(126.48,35.6) v12(126.64,36.7) v12(126.64,36.05)
