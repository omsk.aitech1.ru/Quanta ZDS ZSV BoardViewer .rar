# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SRTC_RST#: length 37.6
  TOP w0.117: R89.2 97.78,40.16 C15.1 97.78,40.04 98.25,39.58 98.25,38.43 98.61,38.07 98.61,37.5 98.86,37.24 98.86,36.55 98.23,35.91 98.23,33.22 98.39,33.06 98.39,32.8 99.79,31.4 99.79,31.01 99.94,30.86 99.94,30.54 v4(100.15,30.33) 99.94,30.13 99.94,28.63 v2(100.04,28.53)
  IN1 w0.06: v11(112.74,35.81) 112.42,35.81 112.16,35.55 112.07,35.55 111.83,35.31 111.63,35.31 111.27,34.96 111.27,34.64 110.09,33.46
  IN1 w0.071: v2(100.04,28.53) 100.18,28.66 102,28.66 103.04,29.7 103.04,29.89 106.31,33.16 108.07,33.16 108.37,33.46 110.09,33.46
  GND1 w0.117: v2(100.04,28.53) 99.79,28.28 v9(99.71,28.28)
  GND2 w0.117: v7(99.43,28.05) 99.43,28.1 99.61,28.28 v9(99.71,28.28)
  IN4 w0.071: v7(99.43,28.05) 98.93,27.54 94.46,27.54 v8(93.54,26.63)
SSD_PEDET: length 7
  TOP w0.117: v3(110,53.3) 110.05,53.25 111.14,53.25 T7.1
  IN2 w0.094: v3(110.84,47.89) 110.84,48.28 110.69,48.43 110.69,52.61 v3(110,53.3)
SSDE: length 3.7
  BOTTOM w0.117: R366.1 R347.1 253.2,17.79 252.98,18.02 252.98,18.42 251.98,19.42 U13.3
SSEQ: length 3.3
  BOTTOM w0.191: R318.1 R319.1 v4(247.82,20.91) 248.41,21.5 U13.11
SSRXN: length 2
  BOTTOM w0.117: U13.4 251.58,19.33 252.06,18.85 252.06,18.69 C347.2
SSRXP: length 2
  BOTTOM w0.117: U13.5 251.18,19.31 251.76,18.73 251.76,18.58 C346.2
SSTXN: length 3.8
  BOTTOM w0.117: U13.7 250.38,19.25 250.03,18.9 248.45,18.9 248.14,18.59 248.14,18.4 C343.2
SSTXP: length 3.8
  BOTTOM w0.117: C342.2 247.84,18.48 247.84,18.72 248.33,19.2 249.91,19.2 249.98,19.28 U13.8
SUSACK#_EC: length 66
  TOP w0.117: R108.2 101.7,36.27 100.83,35.4 v3(100.83,35.31)
  IN2 w0.094: v4(57.63,13.66) 57.63,14.1 58.21,14.68 63.41,14.68 63.83,14.26 72.2,14.26 73.47,15.54 81.6,15.54 81.78,15.36 85.53,15.36 87.37,17.21 89.62,17.21 90.89,18.48 90.89,23.7 90.23,24.36 90.23,27.03 91.62,28.42 93.16,28.42 98.79,34.05 98.91,34.05 100.32,35.46 100.68,35.46 v3(100.83,35.31)
  BOTTOM w0.076: 56.64,13.17 54.3,13.17 54.15,13.01 54.15,12.17 U17.F4
  BOTTOM w0.117: 56.64,13.17 57.14,13.17 v4(57.63,13.66)
SUSACK#_EC_R: length 9.7
  TOP w0.117: R109.2 102.94,36.28 v1(102.84,36.18) 102.76,36.1 102.25,36.1 102.15,36.2 R108.1
  IN1 w0.06: v11(110.29,36.36) 109.85,36.36 109.31,35.82 109.3,35.82
  IN1 w0.071: v1(102.84,36.18) 103.27,35.75 105.17,35.75 105.49,36.06 107.44,36.06 107.8,35.71 109.18,35.71 109.3,35.82
SUSCLK: length 219.4
  TOP w0.117: Q4.3 191,40.83 192.9,42.72 v4(192.9,46.59) 192.9,50.42 193.44,50.96 v4(194.15,50.96) ; R98.1 102.36,38.39 v3(102.58,38.16)
  IN2 w0.064: 105.55,38.03 106.45,37.13 108.34,37.13 108.8,37.6 109.21,37.6 109.57,37.96 110.36,37.96 110.55,37.76 111.39,37.76 111.61,37.54 v3(111.8,37.54) 112.01,37.74 112.01,38.62 111.59,39.03 ; 99.13,38.57 99.16,38.59 102,38.59 102.44,38.16 v3(102.58,38.16)
  IN2 w0.066: 111.52,39.11 111.59,39.03 ; 105.55,38.03 104.77,38.03 104.64,38.16 v3(102.58,38.16)
  IN2 w0.094: 111.52,39.11 111.52,39.19 111.17,39.54 111.17,40.42 111.05,40.54 111.05,41.01 111.15,41.11 111.15,41.4 111.14,41.41 110.99,41.56 110.99,41.94 111.14,42.1 111.14,42.81 110.59,43.36 110.59,44.46 110.66,44.53 110.66,45.72 110.99,46.04 111,46.04 111.44,46.49 111.73,46.49 111.95,46.71 113.19,46.71 113.84,47.36 113.84,47.77 114.09,48.03 114.69,48.03 v9(114.75,47.97) ; 99.13,38.57 97.69,38.57 96.22,37.09 96.22,35.76 95.17,34.7 94.38,34.7 92,32.33 90.42,32.33 89,30.91 87.66,30.91 84.67,27.92 77.65,27.92 76.38,29.19 72.34,29.19 71.07,30.46 67.8,30.46 67.11,29.77 64.96,29.77 64.37,29.17 57.94,29.17 55.92,27.16 51.94,27.16 48.25,30.84 48.25,35.41 49.09,36.25 49.09,38.61 46.52,41.18 45.05,41.18 43.89,42.35 43.89,44.03 44.57,44.71 44.57,47.76 43.28,49.05 43.28,50.53 43,50.81 42.46,50.81 41.83,50.17 v3(41.83,50.15)
  IN3 w0.094: v4(194.15,50.96) 194.07,51.04 191.88,51.04 190.7,52.22 176.11,52.22 175.04,51.16 166.61,51.16 158.76,59.01 124.96,59.01 120.67,54.72 116.15,54.72 114.95,53.53 114.95,50.43 113.91,49.38 113.91,48.5 114.44,47.97 v9(114.75,47.97)
SUSCLK_R: length 2
  TOP w0.117: R63.2 40.79,49.65 39.24,49.65 CN2.68
SUSCLK_WLAN: length 9.9
  TOP w0.117: CN1.50 200.38,39.35 200.29,39.44 R91.2 199.3,39.27 199.14,39.11 198.31,39.11 197.71,39.71 196.83,39.71 v4(196.09,40.45) 195.53,41 Q4.1
SUSLED#: length 221.1
  IN3 w0.094: v8(52.14,7.68) 52.31,7.68 52.79,7.2 53.73,7.2 54.17,6.75 55.73,6.75 56.37,7.4 57.5,7.4 58.29,8.19 58.29,8.75 60.63,11.09 63.48,11.09 64.67,12.28 66.29,12.28 67.74,13.73 71.65,13.73 72.45,14.53 79.71,14.53 80.42,13.81 86.82,13.81 87.57,14.56 89.85,14.56 96.57,7.84 98.98,7.84 99.64,7.18 102.41,7.18 102.9,6.69 131.93,6.69 132.16,6.45 139.36,6.45 140.35,7.44 145.6,7.44 145.78,7.63 146.55,7.63 146.84,7.35 158.52,7.35 160.5,5.37 171,5.37 171.19,5.18 176.82,5.18 179.73,8.09 179.73,9.76 182,12.02 185.11,12.02 186.37,13.28 188.56,13.28 189.29,12.55 193.98,12.55 194.53,13.11 196.82,13.11 201.57,17.86 201.57,23.98 199.03,26.52 199.03,36.28 198.06,37.26 198.06,38.48 196.82,39.72 196.82,42.82 197.37,43.36 197.37,47.45 194.59,50.23 189.85,50.23 v4(188.97,51.11)
  BOTTOM w0.076: U17.M6 52.14,8.17 v8(52.14,7.68)
  BOTTOM w0.117: R153.1 189.83,54.25 189.83,51.98 v4(188.97,51.11) 187.67,52.41 183.48,52.41 v4(183.19,52.7) 182.73,53.16 R150.1
SUSPWRDNACK#: length 69
  TOP w0.117: v3(92.53,31.45) 92.86,31.78 v4(93.08,31.78) 93.67,31.78 93.88,31.99 R136.2
  IN2 w0.094: v9(45.54,7.02) 45.54,8.06 47.42,9.94 v4(47.42,17.97) 47.42,18.32 48.01,18.91 50.69,18.91 50.97,18.63 53.28,18.63 55.01,20.36 55.01,23.63 60.05,28.67 66.26,28.67 66.46,28.47 76.08,28.47 77.48,27.07 85.38,27.07 87.7,29.39 87.7,29.71 88.09,30.1 89.24,30.1 90.37,31.22 92.3,31.22 v3(92.53,31.45)
  GND2 w0.127: v9(45.54,7.02) 45.54,7.01 v8(45.54,6.69)
  BOTTOM w0.117: R352.2 v4(47.42,17.97)
SUSPWRDNACK#_R: length 22.5
  TOP w0.117: R136.1 94.33,31.53 94.86,31 v4(96.13,31) 96.13,30.56 v3(96.41,30.28) ; v3(103.63,35.24) 103.63,36.13 103.75,36.25 103.75,36.49 103.46,36.79 R109.1 103.17,37.01 103.17,37.03 103.05,37.15 R102.2
  IN1 w0.071: v3(103.63,35.24) 103.74,35.35 105.6,35.35 105.92,35.67 107.28,35.67 108.02,34.93 109.29,34.93 109.44,35.08 109.47,35.08 v11(109.59,35.21)
  IN2 w0.094: v3(96.41,30.28) 97.25,31.12 97.38,31.12 98.19,31.94 98.19,32.76 99.87,34.43 99.87,34.47 100,34.6 100.39,34.99 100.69,34.99 100.75,35.05 101,35.05 101.18,35.24 v3(103.63,35.24)
SW0: length 1.8
  BOTTOM w0.117: R255.1 249.31,26.65 249.81,26.65 249.98,26.49 U13.21
SW1: length 1.4
  BOTTOM w0.117: U13.22 250.38,26.34 R256.1
SW2: length 4.1
  BOTTOM w0.117: U13.23 250.78,26.44 250.18,27.03 250.18,27.54 249.77,27.95 R241.1 249.77,28.53 249.96,28.71 249.96,29.47 v4(249.93,29.5)
SW_CORE: length 14.9
  IN4 w0.508: v5(180.21,28.51) 180.21,29.38 v5(182.57,31.74) 183.26,32.43 183.26,40.07 v5(182.77,40.55)
  BOTTOM w0.203: v5(180.21,28.51) 179.72,28.03 PU12.24
  vias: v4(183.61,31.12)
SW_GT1: length 14.9
  IN4 w0.508: v5(173.07,40.25) 173.78,39.54 v5(173.78,31.69) 173.78,29.94 175.26,28.46 v5(176.19,28.46)
  BOTTOM w0.203: PU12.16 176.52,28.12 v5(176.19,28.46)
  vias: v4(171.7,38.84)
SW_SA:
  vias: v4(160.14,50.2) v4(160.34,50.93) v4(161.41,52.41) v5(160.5,52.54)
SWN_CORE: length 26.6
  TOP w0.203: v4(187.17,24.76) 187.34,24.94 187.34,31.27 187.89,31.82 187.89,34.28 189.1,35.49 189.1,39.55 188.88,39.77 187.97,39.77 186.84,40.9 185.13,40.9 183.78,42.25 183.78,44.19 183.57,44.39 PR34.1
  BOTTOM w0.203: PR228.2 186.95,24.55 v4(187.17,24.76)
SWN_GT1: length 22.2
  TOP w0.203: v4(169.54,30.84) v4(168.4,31.99) 167.72,32.66 167.72,34.6 168.99,35.87 168.99,40.46 169.51,40.99 172.05,40.99 173.6,42.53 173.6,44.14 173.81,44.34 PR36.1
  BOTTOM w0.117: v4(169.13,30.16) 169.13,30.67 169.31,30.84 v4(169.54,30.84)
  BOTTOM w0.203: PR186.1 170.53,30.25 170.53,30.25 PR184.1 169.54,30.77 v4(169.54,30.84)
SWN_SA: length 57.5
  TOP w0.203: PR17.1 153.76,50.43 153.37,50.04 153.37,48.03 154.12,47.29 154.12,45.19 156.81,42.5 162.81,42.5 165.62,39.7 165.62,21.31 167.25,19.67 168.57,19.67 171.07,17.18 173.69,17.18 174.09,17.57 175.7,17.57 177.34,15.92 179.01,15.92 179.19,16.1 v4(179.19,16.11)
  BOTTOM w0.203: PR295.1 181.35,16.04 180.91,15.59 179.88,15.59 179.36,16.11 v4(179.19,16.11)
SWVR1:
  vias: v4(57.45,40.98) v4(58.11,40.98) v4(64.45,39.19)
SWVR3:
  vias: v4(75.3,41.61) v5(79.78,41.6)
SWVR4:
  vias: v4(72.26,55.38) v4(73.88,56.07) v5(74.37,56.66)
SWVR5:
  vias: v4(55.59,48.83) v4(59.46,47.96) v4(60.14,49.26) v4(60.14,48.6)
SYS_I: length 30.8
  IN3 w0.094: v4(60.57,17.85) 60.08,17.35 50.35,17.35 48.83,15.82 47.9,15.82 47.79,15.93 45.37,15.93 45.11,16.2 43.36,16.2 v4(42.31,15.15)
  BOTTOM w0.117: v4(42.31,15.15) 42.62,14.83 42.62,14.83 42.72,14.74 42.72,13.34 v4(43.99,12.07) 44.11,11.95 45.26,11.95 PC231.1 46.36,11.38 46.82,10.91 U17.G13
  BOTTOM w0.203: PR279.1 61.98,17.7 61.59,18.09 60.82,18.09 v4(60.57,17.85)
SYS_PWROK: length 51.2
  TOP w0.117: v3(100.99,52.75) 101.07,52.75 101.47,52.34 101.47,51.8 101.55,51.72 R36.2 R41.2
  GND1 w0.102: v2(69.02,43.23) 69.12,43.13 v9(69.49,43.13)
  IN2 w0.094: v3(100.99,52.75) 100.99,54.69 99.26,56.42 98.47,56.42 98.04,55.99 v4(96.89,55.99)
  GND2 w0.127: v9(69.49,43.13) 69.26,43.13 v8(69.16,43.22)
  IN4 w0.071: v4(96.89,55.99) 96.89,55.63 94.53,53.27 90.77,53.27 89.15,54.9 89.15,57.34 88.68,57.81 88.51,57.81 88.25,58.07 85.52,58.07 84.83,57.39 84.83,56.55 83.81,55.53 81.88,55.53 76.93,50.59 75,50.59 73.54,49.13 72.85,49.13 72.33,48.61 72.33,47.89 70.43,45.99 70.43,44.05 69.6,43.22 v8(69.16,43.22)
  BOTTOM w0.117: PR131.1 69.34,43.4 v8(69.16,43.22)
SYS_PWROK_R: length 9.8
  TOP w0.089: U3.J1 108,47.03 107.31,47.03 106.88,47.46
  TOP w0.117: C4.1 102.45,50.79 R41.1 102,50.12 R42.2 102.21,50.12 v4(102.57,49.77) 102.7,49.63 102.7,48.97 103.22,48.45 104.35,48.45 104.59,48.68 105.71,48.68 106.88,47.51 106.88,47.46
SYS_RST#: length 7.3
  TOP w0.089: 106.88,47.87 107.54,47.21 107.83,47.21 108.27,47.65 U3.H2
  TOP w0.117: 106.88,47.87 105.84,48.9 104.49,48.9 104.24,48.65 103.42,48.65 103.15,48.92 R10972.2 103.15,49.31 103.14,49.31 R45.2
TEMP: length 2.7
  BOTTOM w0.117: BAT1.5 v4(79.57,11.97) 79.57,12.12 79.95,12.5 PR313.1
TEMP_ALERT#: length 2.9
  TOP w0.102: v2(67.33,48.63) 67.33,48.38 67.28,48.33 67.28,47.97 PU5.L2
  GND1 w0.102: v2(67.33,48.63) 67.18,48.63 v9(67.03,48.48)
  GND2 w0.127: v9(67.03,48.48) 67.11,48.48 v8(67.34,48.25)
  BOTTOM w0.117: PR87.1 67.89,48.28 v4(67.85,48.24) 67.85,48.25 v8(67.34,48.25)
TEMP_MBAT#: length 47.2
  IN3 w0.094: v8(46.09,15.37) 46.09,15.4 46.36,15.66 48.92,15.66 50.45,17.19 59.09,17.19 61.35,14.92 62.28,14.92 62.49,15.14 66.26,15.14 66.59,15.46 68.73,15.46 v4(68.85,15.59)
  BOTTOM w0.117: v8(46.09,15.37) 46.09,15.3 45.59,14.8 45.59,13.06 45.91,12.74 46.29,12.74 46.98,12.05 v4(47.49,12.05) 47.73,12.28 48.35,12.28 48.72,11.91 U17.E13 ; PR304.2 68.77,15.5 v4(68.85,15.59) 68.94,15.59 69.34,15.98 69.84,15.98 72.78,13.05 73.21,13.05 v4(73.58,12.68) 73.93,12.33 74.14,12.33 74.45,12.02 75.84,12.02 76.54,11.32 77.97,11.32 78.18,11.52 78.18,12.91 78.55,13.28 PR312.1 PR313.2
THRMTRIP#: length 31.2
  TOP w0.117: C2.1 100.78,58.55 v4(100.58,58.76) 100.78,58.96 R2.1 100.78,59.48 Q2.1
  IN4 w0.071: v4(100.58,58.76) 100.98,58.35 106.24,58.35 107.03,57.56 113.23,57.56 113.4,57.74 115.6,57.74 v8(119.35,53.99)
  BOTTOM w0.117: v8(119.35,53.99) 120.99,53.99 121.18,53.8 v4(121.18,53.8) 122.22,52.76 122.22,51.69 122.61,51.3 122.61,50.65 121.88,49.92 121.88,49.71 121.69,49.52 R172.1
TI_BFET#_TYPEC1: length 3.4
  BOTTOM w0.254: v4(201.64,25.31) 201.47,25.31 200.52,24.36 R283.2 200.14,23.6 U10.9
TI_BFET#_TYPEC2: length 4.1
  BOTTOM w0.117: U43.9 201.03,5.7 201.79,4.94 R11003.2 201.29,4.18 201.29,2.95 v4(201.42,2.83)
TOUCH_INT#: length 8.3
  TOP w0.089: v1(107.41,47.82) 107.41,48.25 107.31,48.35
  TOP w0.117: T17.1 103.99,50.26 104.58,49.67 105.91,49.67 107.23,48.35 107.31,48.35
  IN1 w0.071: v11(110.29,46.72) 110.29,46.81 110.02,47.08 109.7,47.08 109.04,47.74 108.92,47.74 108.72,47.94 107.54,47.94 107.42,47.82 v1(107.41,47.82)
TP_DDR0_ALERT#: length 1.4
  GND1 w0.06: v2(125.33,36.06) 125.42,36.15 v9(125.42,36.41)
  GND2 w0.127: v8(125.72,36.71) v9(125.42,36.41)
  BOTTOM w0.117: T46.1 125.78,36.72 125.77,36.71 v8(125.72,36.71)
TP_DDR0_PARITY: length 2.1
  GND1 w0.06: v9(125.06,35.54) 125.06,35.06 125.01,35 v12(125.01,34.83)
  GND2 w0.127: v9(125.06,35.54) 125.09,35.52 125.09,35.42 v8(125.5,35.02)
  BOTTOM w0.117: T50.1 125.37,35.19 125.5,35.06 v8(125.5,35.02)
TPCLK: length 99.7
  IN3 w0.094: v8(46.7,15.15) 46.76,15.2 49.7,15.2 49.93,14.97 50.74,14.97 51.73,15.96 58.57,15.96 60.09,14.43 62.55,14.43 62.78,14.66 66.65,14.66 66.82,14.83 70.27,14.83 71.13,15.7 79.6,15.7 79.99,16.09 81.58,16.09 81.97,15.7 85.81,15.7 87.3,17.18 89.24,17.18 97.46,8.96 99.62,8.96 100.16,8.42 103.09,8.42 103.75,7.76 132.59,7.76 v8(132.89,8.06)
  BOTTOM w0.076: U17.D9 50.64,12.66 49.14,12.66
  BOTTOM w0.117: R441.1 132.9,8.23 R444.1 ; 49.14,12.66 48.04,12.66 46.63,14.08 v4(46.63,14.64) 46.7,14.71 v8(46.7,15.15)
TPCLK_C: length 32.4
  IN4 w0.071: v8(159.35,8.85) 158.82,9.38 157.83,9.38 157.37,9.84 145.49,9.84 145.33,9.99 143.13,9.99 142.55,10.57 141.4,10.57 v8(141.07,10.9)
  BOTTOM w0.117: v8(159.35,8.85) 159.45,8.75 CN16.7 ; v8(141.07,10.9) 141.07,10.37 v4(141.32,10.12) 142.1,9.34 CN12.3 142.1,7.52 141.84,7.26 140.47,7.26 139.87,7.86 136.3,7.86 D30.1 135.7,7.83 135.39,7.83 C430.2 134.99,8.22 R441.2
TPD_EN: length 129.4
  IN3 w0.094: v7(61.11,13.65) 60.93,13.82 59.87,13.82 58.33,15.35 52.25,15.35 51.15,14.26 49.93,14.26 49.32,14.87 46.58,14.87 46.37,15.07 45.97,15.07 45.76,15.27 v8(45.76,15.58)
  IN4 w0.071: v8(162.55,9.08) 162.45,8.97 160.12,8.97 158.69,10.4 146.45,10.4 146.08,10.77 145.33,10.77 145.13,10.57 143.43,10.57 142.56,11.44 140.51,11.44 139.12,10.05 99.18,10.05 95.14,14.09 83.68,14.09 83.37,13.78 68.15,13.78 67.58,13.21 61.54,13.21 v7(61.11,13.65)
  BOTTOM w0.117: v8(162.55,9.08) 162.55,8.72 162.45,8.62 CN16.1 ; U17.C13 48.84,12.96 48.23,12.96 47.24,13.95 47.24,14.97 47.03,15.17 47.03,15.38 46.6,15.8 46.27,15.8 46.27,15.81 46.09,15.81 45.87,15.58 v8(45.76,15.58) 45.76,15.88 v4(45.54,16.11)
TPD_INT#: length 171.2
  IN1 w0.06: v11(110.56,43.85) 110.56,43.95 110.28,44.23 110.28,44.51 110.13,44.66 109.95,44.66 109.8,44.51 109.8,44.38 109.62,44.2 109.44,44.2 109.32,44.33 109.32,44.53 109.47,44.69 109.47,44.87 109.32,45.02 108.6,45.02 108.53,45.09 107.71,45.09 107.64,45.02
  IN1 w0.071: v4(100.43,10.58) 100.43,10.8 99.82,11.41 99.61,11.41 97.1,13.93 97.1,22.66 94.63,25.13 94.63,27.49 95.45,28.3 95.45,30.08 96.44,31.07 96.44,34.96 96.72,35.24 96.72,39.1 97.56,39.94 97.56,41.13 97.47,41.22 97.47,42.67 98.34,43.54 98.34,44.11 98.54,44.31 98.54,44.47 98.66,44.58 103.42,44.58 104.01,45.17 104.46,45.17 104.77,44.86 105.89,44.86 106.12,44.64 107.08,44.64 107.33,44.89 107.51,44.89 107.64,45.02
  IN4 w0.071: v8(58.16,11.62) 58.62,12.07 58.62,13.99 58.86,14.23 61.33,14.23 62.07,13.49 67.47,13.49 68.03,14.05 83.26,14.05 83.56,14.36 96.26,14.36 100.04,10.58 v4(100.43,10.58) 100.66,10.34 138.03,10.34 139.42,11.73 142.68,11.73 142.99,11.42 143.47,11.42 144.04,10.84 144.81,10.84 145.14,11.18 146.12,11.18 146.61,10.69 159.11,10.69 160.22,9.58 163.64,9.58 v8(163.69,9.63)
  BOTTOM w0.076: U17.F2 54.64,11.67 56.64,11.67
  BOTTOM w0.117: CN16.2 161.95,8.7 162.3,9.05 162.3,9.43 162.49,9.62 162.87,9.62 162.88,9.63 v8(163.69,9.63) ; 56.64,11.67 v4(57.02,11.67) 58.11,11.67 v8(58.16,11.62)
TPDAT: length 92.1
  IN3 w0.094: v8(132.91,7.3) 132.74,7.47 103.63,7.47 103.03,8.06 100.07,8.06 99.49,8.64 97.2,8.64 88.97,16.87 87.6,16.87 86.1,15.37 81.83,15.37 81.43,15.78 80.21,15.78 79.8,15.37 71.98,15.37 71.12,14.52 66.98,14.52 66.8,14.33 62.88,14.33 62.67,14.12 59.99,14.12 58.45,15.65 51.93,15.65 50.88,14.59 v8(50.31,14.59)
  BOTTOM w0.076: v8(50.31,14.59) 50.64,14.27 50.64,13.66 U17.B9
  BOTTOM w0.117: R450.1 132.93,7.09 R451.1 v4(133.75,6.36)
TPDAT_C: length 33.2
  IN4 w0.071: v8(159.73,8.92) 158.97,9.68 157.96,9.68 157.52,10.12 145.64,10.12 145.46,10.29 143.26,10.29 142.67,10.88 141.5,10.88 v8(141.47,10.9)
  BOTTOM w0.117: R451.2 134.99,7.09 C439.2 134.99,7.14 135.36,7.51 135.69,7.51 D32.1 136.36,7.54 139.73,7.54 140.05,7.22 140.05,7.22 140.33,6.94 142.13,6.94 142.6,7.41 CN12.2 v4(142.6,9.13) 142.6,9.47 141.47,10.6 v8(141.47,10.9) ; CN16.6 159.95,8.71 v8(159.73,8.92)
TS_EN: length 214.8
  IN3 w0.094: v8(45.13,19.22) 45.34,19.22 45.8,19.68 45.8,20.97 49.27,24.44 50.49,24.44 50.92,24.87 58.08,24.87 61.11,21.85 61.94,21.85 64.46,24.37 67.79,24.37 68.68,25.25 71,25.25 71.86,26.12 78.25,26.12 79.2,25.16 84.54,25.16 85.15,24.55 86.73,24.55 88.2,23.07 89.73,23.07 92.33,20.47 92.33,18.14 92.33,17.4 100.53,9.2 127.12,9.2 127.23,9.09 132.12,9.09 132.23,9.2 138.96,9.2 139.14,9.01 139.56,8.59 145.16,8.59 145.31,8.75 147.02,8.75 147.3,8.47 154.02,8.47 160.73,15.18 160.73,18.2 161.63,19.1 165.39,19.1 168.3,16.19 171.39,16.19 174.51,13.07 182.4,13.07 183.58,14.24 191.95,14.24 198.03,20.32 198.03,21.94 198.24,22.15 198.24,30.91 196.57,32.58 196.57,35.21 197.38,36.02 197.38,38.22 195.89,39.71 195.89,44.83 v4(196.54,45.47)
  BOTTOM w0.117: CN6.5 199.3,50.8 198.9,50.4 197.78,50.4 197,49.61 197,46.93 196.41,46.34 196.41,46.02 196.54,45.89 v4(196.54,45.47)
TS_EN_EC: length 9.6
  BOTTOM w0.117: v4(45.05,19.82) 44.82,19.58 44.82,19.06 45.12,18.76 R338.2 45.13,17.96 C349.1 45.89,17.2 45.89,16.44 46.35,15.98 46.68,15.98 47.21,15.45 47.21,15.25 47.7,14.76 47.7,13.81 48.34,13.16 49.14,13.16 U17.C12
TSENSE_CORE: length 4
  BOTTOM w0.198: PU12.27 181.73,26.86
  BOTTOM w0.203: 181.73,26.86 182.06,27.19 v4(182.06,27.21) 183,28.15 PC140.1 183.78,28.85 PR190.2
TSENSE_GT: length 4.9
  BOTTOM w0.203: 172.31,26.7 PC147.1 ; 172.31,26.7 172.31,26.53 172.1,26.33 171.63,26.33 171.25,26.71 PR203.2 ; 172.31,26.7 172.71,26.3 v4(172.99,26.3) 173.76,26.3 174,26.06 PU12.11
TX1N: length 2.3
  BOTTOM w0.076: C299.1 254.97,23.76 254.78,23.76 254.21,23.18 254.04,23.18 253.96,23.1 253.94,23.1 253.94,23.1 U13.34
TX1P: length 2.3
  BOTTOM w0.076: C298.1 254.92,24.03 254.67,24.03 254.1,23.45 253.89,23.45 253.84,23.5 U13.33
TX2N: length 2.8
  BOTTOM w0.076: C313.1 255.43,21.49 255.31,21.37 255.13,21.37 254.27,22.23 253.97,22.23 253.9,22.3 U13.36
TX2P: length 2.8
  BOTTOM w0.076: U13.37 253.93,21.9 254,21.97 254.16,21.97 255.02,21.11 255.35,21.11 255.43,21.02 C323.1
TXD: length 2.2
  BOTTOM w0.117: U20.F1 151.56,3.4 152.29,2.67 T69.1
TYPEC1_CCG1_CC1: length 72.1
  TOP w0.305: CN3.A5 v4(266.31,32.75)
  TOP w0.381: v4(265.42,32.24) 265.8,32.24 v4(266.31,32.75) ; v4(264.31,29.83) 263.77,29.29 260.46,29.29 U4.9 259.96,28.8 259.96,23.8 259.58,23.41 v4(259.58,21.98)
  IN1 w0.381: v4(220.08,11.16) 220.08,11.67 220.42,12 222.32,12 224.2,13.88 228.34,13.88 229.2,13.01 230.62,13.01 230.96,13.36 235.04,13.36 235.67,13.98 238.97,13.98 239.34,14.35 241.98,14.35 242.93,15.3 245.05,15.3 245.36,15.6 247.14,15.6 247.39,15.86 248.28,15.86 249.17,16.75 250.9,16.75 251.07,16.57 254.6,16.57 255.1,17.08 256.16,17.08 258.24,19.15 258.24,20.29 259.58,21.64 v4(259.58,21.98)
  IN3 w0.381: v4(265.42,32.24) 264.53,31.35 264.53,30.06 v4(264.31,29.83)
  BOTTOM w0.305: 220.21,16.21 220.62,16.62 U40.9
  BOTTOM w0.381: v4(220.08,11.16) 220.08,12.51 219.81,12.78 218.74,12.78 218.26,13.27 218.26,14.78 C947.2 218.44,14.96 219.07,15.58 219.07,15.73 219.55,16.21 220.21,16.21
TYPEC1_CCG1_CC2: length 72.5
  TOP w0.381: v4(220.72,11.16) v4(220.72,10.4) ; v4(260.17,21.98) 260.17,23.17 260.55,23.55 260.55,27.74 260.6,27.79 ; v4(264.53,29.19) 264.03,28.68 261.49,28.68
  IN1 w0.381: v4(260.17,21.98) 260.17,21.39 258.82,20.05 258.82,18.9 256.41,16.49 255.34,16.49 254.84,15.99 251.81,15.99 251.47,15.65 249.77,15.65 248.58,14.46 245.51,14.46 245.26,14.71 243.17,14.71 242.22,13.76 239.58,13.76 239.21,13.39 235.91,13.39 235.29,12.77 231.22,12.77 230.88,12.43 228.96,12.43 228.1,13.29 224.44,13.29 222.55,11.4 220.97,11.4 220.73,11.16 v4(220.72,11.16)
  IN3 w0.203: 269.44,34.37 268.73,34.37
  IN3 w0.381: CN3.B5 269.83,34.37 269.44,34.37 ; 268.73,34.37 268.4,34.37 265.12,31.1 265.12,29.4 264.92,29.19 v4(264.53,29.19)
  BOTTOM w0.305: 221.86,16.24 221.62,16.48 U40.7
  BOTTOM w0.381: 221.86,16.24 221.99,16.11 221.99,15.86 222.36,15.48 222.36,14.59 222.63,14.32 C948.2 222.88,14.08 222.02,13.22 222.02,12.45 221.86,12.3 221.1,12.3 220.72,11.92 v4(220.72,11.16)
TYPEC1_CCG1_VBUS_C_CTRL: length 12.7
  IN1 w0.071: v4(218.31,18.4) 217.93,18.02 213.99,18.02 v4(213.26,18.75)
  BOTTOM w0.117: v4(212.59,19.16) 213,18.75 v4(213.26,18.75) PR330.2 213.26,17.9 213.35,17.8 213.75,17.8 214,17.54 214,16.25 213.72,15.97 PU18.1 212.94,15.53 213.13,15.35 PR496.2 ; v4(218.31,18.4) 218.46,18.55 U40.12
TYPEC1_CCG1_VBUS_DISCHARGE: length 15.6
  TOP w0.117: v4(211.32,24.19) 211.91,23.6 213.23,23.6 213.86,24.24 v4(214.37,24.24) 217.93,24.24 v4(218.05,24.11)
  BOTTOM w0.117: U40.20 218.6,22.55 218.05,23.1 v4(218.05,24.11) ; v4(211.32,24.19) 211.65,23.86 211.65,22.38 211.96,22.08 212.46,22.08 212.72,21.83 PQ15.5 212.72,20.43 213.26,19.89 PR324.2
TYPEC1_CCG1_VBUS_P_CTRL: length 25.3
  IN1 w0.071: v4(199.55,14.12) 201.07,14.12 202.3,15.35 207,15.35 209.39,17.74 218.26,17.74 v4(218.31,17.79)
  BOTTOM w0.117: U11.1 198.73,14.7 v4(198.37,14.33) 198.76,13.94 198.99,13.94 199.1,13.82 R10962.2 R265.1 199.79,13.94 199.61,14.12 v4(199.55,14.12) ; U40.11 218.57,18.05 v4(218.31,17.79)
TYPEC1_EN: length 37.1
  TOP w0.117: v4(218.31,21.32) 218.31,20.56 217.86,20.11 217.86,15.54 v4(218.24,15.16) 218.24,14.78 220.34,12.68 221.79,12.68 225.47,16.36 229.51,16.36 230.65,15.22 234.94,15.22 236.72,17 v4(237.86,17)
  IN1 w0.071: v4(214.88,21.57) 215.13,21.32 v4(218.31,21.32)
  BOTTOM w0.117: Q29.2 237.48,17.63 237.86,17.25 v4(237.86,17) ; v4(214.88,21.57) 215.14,21.31 R10987.2 ; U40.18 218.54,21.55 v4(218.31,21.32)
TYPEC1_SBU1: length 11.7
  IN1 w0.071: v1(267.89,34.25) 268.16,34.25 268.52,33.9 268.52,31.09 268.19,30.77 266.24,30.77 266.19,30.72 v4(265.8,30.72)
  BOTTOM w0.117: v4(265.8,30.72) 265.7,30.61 265.42,30.61 263.5,32.54 U42.5
TYPEC1_SBU2: length 11.6
  IN1 w0.071: v4(265.8,29.95) 265.65,30.11 265.65,30.18 265.8,30.33 266.06,30.33 266.31,30.59 268.27,30.59 268.69,31.02 268.69,32.56 268.75,32.62 269.31,32.62 269.59,32.34 269.82,32.34 269.9,32.42 CN3.B8
  BOTTOM w0.117: U42.6 262.76,32.14 262.86,32.24 263.37,32.24 265.3,30.31 265.78,30.31 265.91,30.19 265.91,30.06 v4(265.8,29.95)
TYPEC1_USB0: length 36.5
  TOP w0.508: v4(186.81,7.42) 186.81,12.35 188.18,13.72 188.67,13.72 190.29,15.35 190.29,18.47 192.25,20.43 192.44,20.43 193.76,21.75 194.34,21.75 196.08,23.49 196.08,27.17 197.01,28.1 199.34,28.1 200.49,26.96 203.91,26.96 v4(204.4,26.46) v4(204.97,25.89)
  BOTTOM w0.508: PD4.2 186.81,7.13 v4(186.81,7.42) ; v4(214.88,20.56) 215.39,20.05 R10988.2
  vias: v1(267.51,34.75) v1(267.58,32.24) v1(267.89,34.75) v1(267.89,32.25) v1(268.22,32.24) v1(268.27,34.75) v2(267.51,34.75) v2(267.58,32.24) v2(267.89,34.75) v2(267.89,32.25) v2(268.22,32.24) v2(268.27,34.75) v3(267.51,34.75) v3(267.58,32.24) v3(267.89,34.75) v3(267.89,32.25) v3(268.22,32.24) v3(268.27,34.75) v4(204.36,24.85) v4(204.97,25.25) v4(204.97,24.62) v4(205.61,25.89) v4(205.61,25.25) v4(205.61,24.62) v4(206.17,25.56) v4(260.98,36.43) v4(261.36,35.41) v4(261.61,36.43) v4(262.25,36.43) v4(262.88,36.43) v4(264.66,36.68) v4(265.8,36.68)
TYPEC1_USB0_EN: length 8.1
  BOTTOM w0.117: U10.2 200.14,18.89 200.03,18.78 R274.2 R292.1 201.15,17.8 201.19,17.76 R10963.1 201.19,16.55 201.25,16.49 U11.4 200.67,16 200.27,15.6 200.27,14.08 200.24,14.05 R265.2
TYPEC1_USB0_R:
  vias: v4(201.8,26.91)
TYPEC2_CCG1_CC1: length 64.5
  TOP w0.305: v4(265.93,21.98) 265.93,19.79 266.98,18.75 CN18.A5
  TOP w0.381: v4(220.21,26.88) 220.21,26.27 v4(219.7,25.76) 219.7,25 220.21,24.49 v4(220.21,24.37)
  IN1 w0.381: v4(263.09,29.83) 261.3,29.83 260.71,30.41 254.58,30.41 251.66,27.49 248.73,27.49 248.27,27.95 221.2,27.95 220.21,26.96 v4(220.21,26.88)
  BOTTOM w0.305: v4(220.21,24.37) 220.24,24.37 220.62,23.98 U40.22
  BOTTOM w0.381: C942.2 v4(220.21,26.88) ; v4(263.09,29.83) 262.8,29.54 U42.9 262.5,29.38 262.5,27.41 263.26,26.65 263.26,24.37 264.28,23.35 264.81,23.35 265.93,22.23 v4(265.93,21.98)
TYPEC2_CCG1_CC2: length 63.9
  TOP w0.381: v4(221.62,24.37) 221.62,25.25 221.23,25.65 v4(221.23,26.02) 221.23,26.52 220.97,26.78 v4(220.97,26.88)
  IN1 w0.381: v4(261.23,28.18) 261.23,29.06 260.47,29.83 254.82,29.83 251.87,26.88 245.64,26.88 245.15,27.36 221.46,27.36 v4(220.97,26.88)
  IN3 w0.178: 268.6,20.38 269.82,20.38 CN18.B5
  IN3 w0.381: 268.6,20.38 267.66,20.38 267.25,19.97 266.72,19.97 265.32,21.37 v4(265.32,21.98)
  BOTTOM w0.305: v4(221.62,24.37) U40.24
  BOTTOM w0.381: v4(220.97,26.88) 220.97,27.28 C941.2 ; v4(261.23,28.18) 261.23,28.98 U42.1 261.74,29.14 261.92,28.96 261.92,27.17 262.63,26.46 262.63,24.17 264.04,22.77 264.53,22.77 v4(265.32,21.98)
TYPEC2_CCG4_VBUS_C_CTRL: length 18
  IN3 w0.094: v8(226.56,18.65) 226.05,18.14 223.13,18.14 221.86,16.87 219.38,16.87 v8(217.19,14.69)
  BOTTOM w0.117: v8(226.56,18.65) 226.16,19.05 U40.38 ; PR502.2 215.48,12.15 215,12.63 215,13.82 215.27,14.09 PU20.1 216.78,14.09 216.89,14.21 PR500.2 v8(217.19,14.69) v4(217.19,15.19)
TYPEC2_CCG4_VBUS_DISCHARGE: length 19.1
  IN3 w0.094: v4(214.67,11.28) 214.67,11.43 215.56,12.32 217.59,12.32 218.8,13.52 220.16,13.52 223.64,17 v4(226.31,17)
  BOTTOM w0.117: v4(225.44,16.75) 226.05,16.75 v4(226.31,17) 226.31,17.81 226.07,18.05 U40.40 ; v4(214.67,11.28) 214.34,10.95 PR501.2 214.34,9.89 214.24,9.79 PQ22.5
TYPEC2_CCG4_VBUS_P_CTRL: length 48.9
  IN3 w0.094: v4(227.07,17) 226.52,17.55 223.77,17.55 220.03,13.82 218.67,13.82 217.47,12.62 215.44,12.62 214.25,11.43 214.25,10.26 211.67,7.68 211.67,6.94 211.67,5.32 209.5,3.16 194.68,3.16 v4(194.25,3.59)
  BOTTOM w0.117: v4(227.07,17) 227.07,17.53 v4(226.84,17.76) 226.05,18.55 U40.39 ; U44.1 192.38,4.95 192.8,4.54 194.25,4.54 194.71,4.07 R11009.1 R11007.2 194.3,3.16 194.25,3.21 v4(194.25,3.59)
TYPEC2_CCG_VBUS_C_CTRL_EC: length 190.1
  IN3 w0.094: v8(48.17,10.23) 48.17,9.49 49.78,7.88 49.78,5.72 51.26,4.24 53.85,4.24 54.4,3.69 56.54,3.69 57.63,2.61 61.29,2.61 65.58,6.89 65.58,7.93 68.99,11.34 73.02,11.34 73.62,11.94 75.01,11.94 75.57,11.39 89.17,11.39 96.27,4.3 130.86,4.3 132.22,2.94 137.02,2.94 137.72,2.24 184.69,2.24 191.1,8.64 199.67,8.64 200.88,9.85 205.16,9.85 208.45,13.15 217.14,13.15 v9(217.19,13.09)
  GND2 w0.127: v8(217.19,13.44) v9(217.19,13.09)
  BOTTOM w0.117: PU20.2 v8(217.19,13.44) ; U17.G12 49.32,10.91 49.07,10.66 48.41,10.66 48.17,10.42 v8(48.17,10.23)
TYPEC2_CCG_VBUS_P_CTRL_EC: length 164.3
  IN3 w0.094: v7(54.2,7.43) 54.48,7.72 55.81,7.72 56.74,8.64 57.3,8.64 60.82,12.16 60.82,12.31 61.54,13.04 66.59,13.04 67.61,14.05 71.52,14.05 72.32,14.85 79.98,14.85 80.2,15.07 81.43,15.07 81.65,14.84 86.64,14.84 87.38,15.58 89.28,15.58 96.7,8.16 99.11,8.16 99.77,7.5 102.57,7.5 103.06,7.01 132.06,7.01 132.3,6.77 139.07,6.77 140.09,7.79 145.5,7.79 145.65,7.95 146.69,7.95 146.97,7.67 158.65,7.67 160.63,5.69 171.17,5.69 171.36,5.5 174.79,5.5 175.48,6.19 175.48,6.64 178.71,9.87 179.4,9.87 181.87,12.34 184.98,12.34 186.24,13.6 191.35,13.6 v7(192.02,12.94)
  IN4 w0.071: v7(192.02,12.94) 192.02,10.14 v8(192.27,9.89) ; v8(53.82,9.77) 53.82,8.77 53.66,8.62 53.66,8.32 54.2,7.79 v7(54.2,7.43)
  BOTTOM w0.076: U17.J4 53.67,9.91 v8(53.82,9.77)
  BOTTOM w0.117: R11016.2 194.56,4.68 194.38,4.86 193.11,4.86 193.03,4.93 U44.2 193.03,8.74 193.29,9 v4(193.29,9.38) 192.78,9.89 v8(192.27,9.89)
TYPEC2_OUT_1-5A: length 176.3
  IN3 w0.094: v8(47.06,16.17) 47.06,16.77 46.02,17.81 46.02,20.87 49.42,24.26 50.57,24.26 50.97,24.67 57.98,24.67 61,21.65 62.12,21.65 64.61,24.14 67.84,24.14 68.73,25.03 70.99,25.03 71.9,25.93 78.21,25.93 79.14,25 84.48,25 85.09,24.39 86.63,24.39 88.84,22.19 90.38,22.19 92.16,20.41 92.16,17.34 100.47,9.04 127.05,9.04 127.16,8.93 132.18,8.93 132.29,9.04 138.89,9.04 138.98,8.95 139.5,8.43 145.23,8.43 145.39,8.59 146.95,8.59 147.23,8.31 156.51,8.31 157.32,9.12 158.1,9.12 160.79,6.43 171.39,6.43 171.61,6.2 174.49,6.2 174.7,6.41 v8(174.7,6.54)
  BOTTOM w0.117: v8(174.7,6.54) 174.7,6.15 174.18,5.64 174.18,3.33 174.1,3.25 v4(174.1,2.4) 174.39,2.12 189.2,2.12 189.99,2.9 Q6071.2 191,2.9 191.38,2.52 R11005.2 ; v8(47.06,16.17) 47.49,15.74 47.49,15.32 47.91,14.9 47.91,13.87 48.37,13.41 U17.B13
TYPEC2_RX1N: length 35.2
  IN3 w0.064: v8(259.54,29.86) 260.02,29.86 260.09,29.93 260.09,30.14 259.99,30.25 258.99,30.25 257.64,28.9 257.64,22.42 259.54,20.52 264.55,20.52 266.69,18.37 266.69,18.14 267.25,17.58 269.58,17.58 CN18.B10
  BOTTOM w0.076: U41.9 259.36,30.1 259.26,30.2 258.93,30.2 256.17,27.43 256.17,25.91 255.39,25.13 254.63,25.13 254.35,24.86 254.35,24.77 254.55,24.57 254.55,24.45 254.4,24.3 254.32,24.3 254.12,24.49 254.02,24.49 253.83,24.3 U13.31
TYPEC2_RX1P: length 35.3
  IN3 w0.064: v8(260.31,30.26) 260.28,30.26 260.08,30.46 258.9,30.46 257.42,28.99 257.42,22.33 259.45,20.3 264.46,20.3 266.48,18.28 266.48,18.05 267.16,17.37 269.63,17.37 CN18.B11
  BOTTOM w0.076: U13.30 253.82,24.7 254.51,25.39 255.28,25.39 255.9,26.02 255.9,27.54 258.82,30.46 259.37,30.46 259.58,30.26 v8(260.31,30.26)
TYPEC2_RX2N: length 27.2
  IN2 w0.064: v3(267.89,21.25) 267.89,21.39 v9(267.46,21.83)
  IN3 w0.064: v8(259.36,27.26) 259.51,27.11 259.51,24.26 260.56,23.21 266.34,23.21 267.46,22.09 v9(267.46,21.83)
  BOTTOM w0.076: v8(259.36,27.26) 259.49,27.26 259.67,27.08 259.67,26.94 258.01,25.28 258.01,22.03 257.87,21.89 257.87,20.47 256.43,19.03 255.14,19.03 254.15,20.02 254.15,20.95 253.99,21.1 U13.39
TYPEC2_RX2P: length 27.2
  IN2 w0.064: v9(267.89,22.21) 268.14,21.95 268.14,21.87 268.02,21.75 v3(267.89,21.75)
  IN3 w0.064: v8(260.31,26.86) 260.25,26.92 259.85,26.92 259.72,26.79 259.72,24.35 260.65,23.43 266.43,23.43 267.65,22.21 v9(267.89,22.21)
  BOTTOM w0.076: U13.40 253.78,20.7 253.88,20.6 253.88,19.91 255.03,18.77 256.54,18.77 258.13,20.36 258.13,21.78 258.27,21.91 258.27,25.17 259.96,26.86 v8(260.31,26.86)
TYPEC2_SBU1: length 31.8
  TOP w0.117: CN18.A8 267.1,20.25 v3(266.97,20.38)
  IN2 w0.094: v3(266.97,20.38) v9(266.69,20.66)
  IN3 w0.094: v9(266.69,20.66) 266.36,20.99 v8(266.36,21.85)
  BOTTOM w0.117: v8(266.36,21.85) 266.36,22.26 266.89,22.79 266.89,24.41 267.66,25.18 267.66,27.85 267.46,28.05 266.64,28.05 263.45,31.24 U42.7 261.97,31.24 261.8,31.42 259.31,31.42 258.82,31.91 257.84,31.91 R11008.2 256.98,31.93 253.69,31.93 253.29,31.53 253.29,27.3 252.38,26.4 U13.27
TYPEC2_SBU2: length 34.6
  BOTTOM w0.117: CN18.B8 269.85,18.65 268.85,18.65 268.47,19.03 268.47,21.57 267.07,22.97 267.07,24.32 267.84,25.08 267.84,27.92 267.53,28.23 266.72,28.23 263.48,31.47 262.01,31.47 261.83,31.64 U42.4 260.9,31.64 260.85,31.6 259.38,31.6 258.89,32.09 257.82,32.09 R11019.2 257.05,32.11 253.61,32.11 253.1,31.61 253.1,27.54 251.98,26.41 U13.26
TYPEC2_TX1N_C: length 28.9
  IN2 w0.064: v9(268.09,18.14) 268,18.06 268,17.49 268.1,17.39 268.25,17.39 268.34,17.48 v3(268.34,17.76)
  IN3 w0.064: v8(259.36,28.96) 259.36,29.06 259.28,29.14 258.82,29.14 258.27,28.59 258.27,22.68 259.54,21.41 264.52,21.41 266.68,19.25 267.62,19.25 268.04,18.83 268.04,18.19 v9(268.09,18.14)
  BOTTOM w0.076: v8(259.36,28.96) 259.27,29.05 258.8,29.05 256.98,27.23 256.98,24.3 256.69,24.01 255.8,24.01 255.72,23.93 255.72,23.79 C299.2
TYPEC2_TX1P_C: length 29.8
  IN2 w0.064: v9(267.58,18.14) 267.79,17.94 267.79,17.35 v3(267.89,17.25)
  IN3 w0.064: v8(260.31,29.36) 258.73,29.36 258.06,28.68 258.06,22.59 259.45,21.19 264.43,21.19 266.59,19.03 267.53,19.03 267.82,18.74 267.82,18.38 v9(267.58,18.14)
  BOTTOM w0.076: v8(260.31,29.36) 259.49,29.36 259.46,29.32 258.69,29.32 256.71,27.34 256.71,24.41 256.58,24.28 256.12,24.28 C298.2
TYPEC2_TX2N_C: length 27.1
  IN3 w0.064: CN18.B3 269.59,21.41 268.74,21.41 268.56,21.23 267.11,21.23 266.76,21.58 266.76,21.96 266.15,22.58 260.18,22.58 258.73,24.02 258.73,27.34 259.36,27.97 v8(259.36,28.16)
  BOTTOM w0.076: C313.2 255.96,21.5 255.96,21.22 256.08,21.1 256.57,21.1 257.03,21.56 257.03,22.06 257.36,22.39 257.36,26.84 258.57,28.06 259.26,28.06 v8(259.36,28.16)
TYPEC2_TX2P_C: length 27.1
  IN3 w0.064: v8(260.31,27.76) 259.45,27.76 258.95,27.25 258.95,24.11 260.27,22.79 266.24,22.79 266.97,22.05 266.97,21.67 267.2,21.44 268.47,21.44 268.65,21.62 269.62,21.62 CN18.B2
  BOTTOM w0.076: C323.2 256.3,20.83 256.68,20.83 257.3,21.44 257.3,21.95 257.63,22.28 257.63,26.73 258.68,27.79 259.8,27.79 259.84,27.76 v8(260.31,27.76)
TYPEC2_USB0: length 5
  TOP w0.305: v1(267.89,20.75) v1(267.51,20.75) 267.13,20.75 266.62,21.27 v4(266.62,23.12) 266.38,23.36 C961.1
  BOTTOM w0.508: R10982.2 v4(229.23,17)
  vias: v1(267.51,18.25) v1(267.89,18.25) v1(268.27,20.75) v1(268.27,18.25) v4(208.53,5.06) v4(208.63,5.98) v4(208.65,6.97) v4(209.04,7.47) v4(209.04,5.44) v4(209.09,6.46) v4(209.54,5.95) v4(209.54,5.06) v4(210.05,5.44) v4(210.43,5.95) v4(210.56,5.06) v4(263.87,24.75) v4(264.38,24.34) v4(264.92,24.75) v4(264.92,23.98)
TYPEC2_USB0_EN: length 8.9
  BOTTOM w0.117: R11000.1 196.72,4.3 v4(196.67,4.35) 196.45,4.56 R11002.1 ; R11002.1 R11001.2 196.34,5.56 196.48,5.7 U43.2 ; R11002.1 195.31,3.92 R11009.2 195.16,3.69 195.45,3.41 195.45,2.88 195.32,2.76 193.95,2.76 193.68,3.02 U44.4
TYPEC2_USB0_R:
  vias: v4(206.37,8.49)
TYPEC_CCG_VBUS_C_CTRL_EC: length 194.6
  IN3 w0.094: v4(212.59,11.92) 211.78,12.73 208.35,12.73 205.31,9.69 200.95,9.69 199.73,8.48 191.16,8.48 184.76,2.08 132.77,2.08 130.71,4.14 96.2,4.14 89.11,11.23 75.5,11.23 74.95,11.78 74,11.78 73.39,11.18 69.21,11.18 66.06,8.03 66.06,6.87 61.39,2.2 54.93,2.2 53.69,3.44 53.28,3.44 53.03,3.69 51.33,3.69 49.57,5.44 49.57,7.58 47.57,9.58 v8(47.57,11.55)
  BOTTOM w0.117: U17.F13 47.7,11.41 v8(47.57,11.55) ; PR335.2 212.98,17.53 213.64,17.53 213.73,17.43 213.73,16.75 213.61,16.62 PU18.2 212.34,16.62 212.19,16.47 212.19,15.76 212.54,15.4 v4(212.54,15.22) 212.54,14.38 212.72,14.21 212.72,12.05 v4(212.59,11.92)
TYPEC_CCG_VBUS_P_CTRL_EC: length 157.6
  IN3 w0.094: v8(55.62,11.92) 56.74,13.04 60.85,13.04 61.2,13.38 66.63,13.38 67.46,14.21 71.45,14.21 72.27,15.02 79.91,15.02 80.16,15.27 81.51,15.27 81.77,15.02 86.56,15.02 87.3,15.76 89.38,15.76 96.79,8.34 99.18,8.34 99.86,7.66 102.63,7.66 103.13,7.17 132.23,7.17 132.43,6.97 138.73,6.97 139.72,7.95 145.43,7.95 145.59,8.11 146.75,8.11 147.03,7.83 156.71,7.83 157.36,8.48 157.36,8.48 157.52,8.64 157.9,8.64 160.7,5.85 171.26,5.85 171.44,5.66 174.72,5.66 175.32,6.26 175.32,6.71 178.65,10.03 179.33,10.03 181.8,12.5 184.91,12.5 186.17,13.76 193.86,13.76 195.45,15.35 v9(198.01,15.35)
  GND2 w0.127: v8(198.34,15.35) v9(198.01,15.35)
  BOTTOM w0.117: U17.E1 55.35,11.91 55.36,11.92 v8(55.62,11.92) ; v4(198.34,16.36) v8(198.34,15.35) U11.2
TYPEC_DDI1_HPD_CPU: length 151.7
  TOP w0.117: v1(110.43,53.53) 110.66,53.75 112.98,53.75 v4(113.15,53.58) 113.5,53.23 113.75,53.23 115.94,51.04 116.65,51.04 117.85,52.23 117.85,52.92 118.84,53.91 122.5,53.91 125.5,56.91 136.04,56.91 137.59,55.35 137.59,53.2 141.41,49.38 v1(141.8,49.38) ; v4(188.92,32.82) 188.92,30.15 188.26,29.5 188.26,23.47 187.8,23.02 185.2,23.02 183.15,20.96 182.19,20.96 179.75,18.52 v1(179.75,18.42)
  IN1 w0.071: v1(110.84,48.88) 111.18,48.88 111.72,49.42 111.72,49.9 112.22,50.41 112.5,50.41 113.35,51.26 113.35,53.37 112.95,53.76 110.67,53.76 v1(110.43,53.53) v2(105.68,53.53) ; v1(179.75,18.42) 181.27,16.9 181.27,15.78 181.15,15.65 175.08,15.65 174.59,16.14 172.76,16.14 172.14,16.76 170.92,16.76 168.45,19.24 166.39,19.24 164.81,20.81 164.81,33.97 163.47,35.31 163.47,39.15 161.26,41.36 155.77,41.36 151.4,45.73 145.46,45.73 141.8,49.38 v1(141.8,49.38)
  GND1 w0.127: v2(105.68,53.53) 106.04,53.53 v9(106.22,53.7)
  GND2 w0.127: v8(105.81,53.7) v9(106.22,53.7)
  BOTTOM w0.117: R142.1 189.22,33.13 v4(188.92,32.82) 188.92,32.06 188.83,31.98 187.07,31.98 186.81,32.24 186.81,32.75 Q8.1 ; R144.2 106.63,55.89 v4(106.29,55.56) 105.81,55.07 v8(105.81,53.7)
TYPEC_DDI2_HPD: length 207.4
  TOP w0.117: v4(225.42,25.13) 224.75,25.13 221.88,28 219.4,28 218.38,26.98 212.77,26.98 211.19,28.56 v4(206.5,28.56) 204.08,28.56 201.8,30.84 v4(201.8,32.54)
  IN1 w0.071: v4(107.54,58.36) 108.11,58.93 109.84,58.93 110.66,59.75 159.98,59.75 167.22,52.51 176.96,52.51 179.52,55.07 195.75,55.07 196.51,54.31 198.24,54.31 201.9,50.65 201.9,33 201.8,32.9 v4(201.8,32.54)
  IN3 w0.094: v8(254.07,23.93) 250.51,23.93 247.72,21.14 243.48,21.14 241.06,23.56 241.06,26.51 239.52,28.05 226.94,28.05 225.42,26.52 v4(225.42,25.13)
  BOTTOM w0.117: v4(107.54,58.36) 107.54,58.38 107.06,58.87 106.18,58.87 105.94,58.63 105.5,58.63 105.27,58.4 R143.2 ; v4(201.8,32.54) 200.86,32.54 199.76,33.64 198.88,33.64 197.73,32.49 194.41,32.49 193.8,33.1 193.8,33.81 193.34,34.27 189.63,34.27 R142.2 188.31,33.86 187.83,33.38 Q8.3 ; 225.42,25.12 R10985.2 ; 225.42,25.12 224.62,24.32 U40.30 ; 225.42,25.12 v4(225.42,25.13) ; v8(254.07,23.93) 254.04,23.9 U13.32
TYPEC_OUT_1-5A: length 180.9
  IN3 w0.094: v8(54.22,6.1) 54.39,6.27 55.92,6.27 56.56,6.91 58.25,6.91 59.68,8.34 60.17,8.34 60.99,9.16 60.99,9.65 61.41,10.07 64.76,10.07 67.94,13.25 71.85,13.25 72.65,14.05 79.51,14.05 80.24,13.32 87,13.32 87.77,14.08 89.65,14.08 96.37,7.36 98.78,7.36 99.44,6.7 102.21,6.7 102.7,6.21 131.73,6.21 131.97,5.97 139.71,5.97 140.7,6.96 145.73,6.96 146.09,6.59 147.5,6.59 147.77,6.87 158.32,6.87 160.91,4.28 170.87,4.28 171.29,4.7 177.02,4.7 180.21,7.89 180.21,9.56 182.2,11.54 185.31,11.54 186.57,12.8 188.36,12.8 189.09,12.07 194.24,12.07 194.8,12.63 197.02,12.63 202.05,17.66 v4(202.05,24.85)
  BOTTOM w0.076: U17.N3 53.89,7.58 53.9,7.56
  BOTTOM w0.117: 53.9,7.56 54.12,7.34 v4(54.12,6.84) 54.12,6.2 v8(54.22,6.1) ; 205.23,19.41 205.23,19.92 204.73,20.42 R264.2 v4(204.73,21.7) 203.83,22.6 203.83,24.37 203.35,24.85 v4(202.05,24.85)
UART2_RXD: length 9.9
  TOP w0.117: v1(100.68,42.1) 100.68,42.73 T25.1
  IN1 w0.06: v11(109.3,42.87) 109.27,42.83 108.79,42.83 108.68,42.72 108.5,42.72 108.33,42.55 106.85,42.55 106.81,42.5 106.22,42.5
  IN1 w0.071: v1(100.68,42.1) 100.86,42.1 100.96,42.2 101.36,42.2 101.91,42.75 105.69,42.75 105.94,42.5 106.22,42.5
UART2_TXD: length 12.4
  TOP w0.117: T23.1 99.2,41.99 99.26,42.05 v1(99.26,42.07)
  IN1 w0.06: 106.22,42.78 107.68,42.78 107.87,42.96 109.06,42.96 109.19,43.09 109.39,43.09 v11(109.75,42.73)
  IN1 w0.071: v1(99.26,42.07) 99.64,41.69 100.12,41.69 100.43,41.99 100.43,42.3 100.6,42.48 101.25,42.48 101.8,43.02 105.85,43.02 106.09,42.78 106.22,42.78
USB3_RXN2: length 179.7
  IN2 w0.094: v9(231.39,27.54) 231.1,27.25 230.84,27.25 230.62,27.48 216.91,27.48 216.46,27.03 215.71,27.03 215.26,27.48 203.82,27.48 200.65,30.65 200.65,33.91 201.14,34.4 201.14,47.43 198.33,50.25 193.74,50.25 190.95,53.04 177.09,53.04 174.05,49.99 164.98,49.99 157.46,57.51 142.93,57.51 142.8,57.38 115.98,57.38 112.09,53.49 112.09,51.47 111.83,51.2 111.83,49.15 v3(111.8,49.12)
  IN3 w0.094: v9(231.39,27.54) 231.62,27.3 231.94,27.3 233.14,26.1 233.14,22.63 237.45,18.31 245.27,18.31 246.12,19.16 251,19.16 252.25,17.91 252.25,17.59 252.34,17.5 v8(252.47,17.5)
USB3_RXN2_B1-: length 36
  TOP w0.117: v4(266.57,35.14) 266.72,35.29 267.16,35.29 267.2,35.25 CN3.A10
  IN3 w0.094: v8(259.93,35.57) 259.79,35.43 257.88,35.43 256.73,34.28 256.73,32.31 252.25,27.83 243.99,27.83 243.14,26.97 243.14,25.69 242.44,24.99 242.44,24.17 242.63,23.98 242.91,23.98 v8(242.97,24.04)
  BOTTOM w0.117: v8(259.93,35.57) 260.03,35.67 263.18,35.67 263.52,36.01 264.19,36.01 264.41,35.8 264.41,35.58 264.52,35.47 264.79,35.47 264.92,35.59 264.92,35.88 265.04,36.01 265.69,36.01 v4(266.57,35.14) ; U15.16 242.47,24.12 242.55,24.03 242.97,24.03 v8(242.97,24.04)
USB3_RXN2_C1-: length 43.5
  IN3 w0.094: v8(259.93,32.97) 259.81,32.85 258.6,32.85 258.37,32.62 258.37,31.47 255.55,28.65 255.55,27.7 253.36,25.51 250.31,25.51 247.9,23.1 245.48,23.1 244.15,21.76 243.74,21.76 241.67,23.82 241.67,26.74 241.85,26.91 242.07,26.91 242.18,26.8 v8(242.18,26.55)
  BOTTOM w0.117: v8(242.18,26.55) 242.18,26.91 242.26,26.99 242.48,26.99 242.65,26.82 242.65,26.01 242.55,25.92 242.41,25.92 242.21,26.12 U15.12 ; v8(259.93,32.97) 259.98,32.92 260.73,32.92 261.09,33.28 263.85,33.28 265.45,31.68 267.71,31.68 267.84,31.81 267.84,32.21 267.96,32.34 268.22,32.34 268.34,32.21 268.34,31.86 268.52,31.68 269.68,31.68 CN3.B10
USB3_RXN2_RE_C2: length 5.7
  IN3 w0.094: v8(235.58,23.96) 235.58,24.03 235.48,24.12 235.48,24.46 236.16,25.13 236.47,25.13 236.91,25.57 238.07,25.57 v8(238.12,25.62)
  BOTTOM w0.117: v8(235.58,23.96) 235.58,24.07 235.47,24.17 235.2,24.17 235.1,24.07 U14.5 ; U15.8 v8(238.12,25.62)
USB3_RXN3: length 164.4
  IN1 w0.06: 112.09,49.75 111.88,49.54 111.88,49.35 112.12,49.11 v1(112.12,48.87)
  IN1 w0.071: v3(112.77,50.05) 112.69,49.96 112.31,49.96 112.09,49.75
  IN2 w0.094: v3(112.77,50.05) 112.9,49.91 113.53,49.91 113.84,50.23 113.84,53.37 116.44,55.96 136.18,55.96 141.87,50.27 144.63,50.27 144.87,50.03 147.51,50.03 149.64,47.9 159.31,47.9 160.16,48.75 174.56,48.75 177.61,51.8 190.3,51.8 193.12,48.98 194.52,48.98 194.94,48.55 196.61,48.55 198.11,47.05 198.11,45.68 199.9,43.9 199.9,37.31 198.95,36.36 198.95,28.5 200.38,27.07 200.38,24.19 206.71,17.86 217.69,17.86 218.14,17.4 219.92,17.4 220.38,17.86 225.2,17.86 225.58,18.23 230.59,18.23 v9(230.75,18.4)
  IN3 w0.094: v8(230.87,23.48) 230.87,23.98 231.04,24.14 231.11,24.14 231.64,23.61 231.64,18.65 231.24,18.25 230.9,18.25 v9(230.75,18.4)
USB3_RXN3_C: length 1.6
  BOTTOM w0.117: U14.7 232.41,24.07 232.15,23.81 231.98,23.81 C339.2
USB3_RXP2: length 179.7
  IN2 w0.094: v9(231.39,27.03) 230.75,27.03 230.53,27.26 217,27.26 216.55,26.81 215.62,26.81 215.17,27.26 203.73,27.26 200.43,30.56 200.43,34 200.92,34.49 200.92,47.34 198.23,50.03 193.65,50.03 190.86,52.81 177.19,52.81 174.14,49.77 164.89,49.77 157.37,57.29 143.02,57.29 142.9,57.16 116.08,57.16 112.31,53.4 112.31,51.37 112.06,51.12 112.06,49.01 111.8,48.75 v3(111.8,48.63)
  IN3 w0.094: v8(251.45,17.5) 251.46,17.51 251.94,17.51 252.03,17.59 252.03,17.82 250.91,18.94 246.21,18.94 245.37,18.09 237.36,18.09 232.92,22.54 232.92,26.01 231.85,27.08 231.44,27.08 v9(231.39,27.03)
USB3_RXP2_B1+: length 36
  TOP w0.117: CN3.A11 267.31,35.75 267.15,35.59 266.72,35.59 v4(266.57,35.75)
  IN3 w0.094: v8(258.98,35.97) 258.98,35.83 258.8,35.65 257.79,35.65 256.51,34.38 256.51,32.4 252.16,28.05 243.9,28.05 242.92,27.06 242.92,25.78 242.22,25.08 242.22,24.08 242.54,23.76 242.92,23.76 v8(242.97,23.71)
  BOTTOM w0.117: v8(242.97,23.71) 242.94,23.73 242.55,23.73 242.44,23.62 U15.17 ; v4(266.57,35.75) 266.38,35.75 265.82,36.31 263.39,36.31 263.06,35.97 258.98,35.97 v8(258.98,35.97)
USB3_RXP2_C1+: length 43.6
  IN3 w0.094: v8(242.44,27.29) 242.28,27.13 241.76,27.13 241.45,26.83 241.45,23.73 243.64,21.54 244.24,21.54 245.58,22.87 247.99,22.87 250.4,25.29 253.45,25.29 255.77,27.61 255.77,28.56 258.59,31.38 258.59,32.53 258.69,32.63 258.92,32.63 v8(258.98,32.57)
  BOTTOM w0.117: v8(242.44,27.29) 242.61,27.29 242.94,26.95 242.94,25.89 242.67,25.62 U15.13 ; CN3.B11 269.62,31.38 265.33,31.38 263.72,32.98 261.21,32.98 260.85,32.62 259.03,32.62 v8(258.98,32.57)
USB3_RXP2_RE_C2: length 5.7
  IN3 w0.094: v8(235.96,24.11) 235.81,24.11 235.71,24.21 235.71,24.37 236.25,24.91 236.56,24.91 237,25.35 238.02,25.35 v8(238.12,25.25)
  BOTTOM w0.117: v8(238.12,25.25) 238.26,25.12 U15.7 ; v8(235.96,24.11) 235.6,24.47 U14.4
USB3_RXP3: length 164.3
  IN1 w0.071: v1(112.12,49.42) 112.12,49.29 112.31,49.11 112.41,49.11 112.52,49.21 112.52,49.38 112.3,49.6 112.3,49.7 112.38,49.78 112.7,49.78 v3(112.78,49.7)
  IN2 w0.094: v3(112.78,49.7) 112.79,49.69 113.62,49.69 114.06,50.14 114.06,53.27 116.53,55.74 136.09,55.74 141.78,50.05 144.54,50.05 144.78,49.81 147.42,49.81 149.55,47.68 159.4,47.68 160.25,48.53 174.66,48.53 177.7,51.57 190.21,51.57 193.03,48.76 194.43,48.76 194.85,48.33 196.52,48.33 197.89,46.96 197.89,45.59 199.68,43.81 199.68,37.4 198.72,36.45 198.72,28.41 200.16,26.97 200.16,24.09 206.62,17.63 217.6,17.63 218.05,17.18 220.01,17.18 220.47,17.63 225.29,17.63 225.67,18.01 230.63,18.01 v9(230.75,17.89)
  IN3 w0.094: v9(230.75,17.89) 230.9,18.03 231.34,18.03 231.86,18.56 231.86,23.71 231.2,24.37 v8(230.87,24.37)
USB3_RXP3_C: length 1.6
  BOTTOM w0.117: C333.2 231.9,24.11 232.02,24.11 232.38,24.47 U14.8
USB3_TXN2: length 176.4
  IN2 w0.066: v3(111.8,48.13) 111.76,48.17 111.76,48.31 111.83,48.38 111.96,48.38 112.03,48.45 112.03,48.78 112.27,49.02 112.27,49.15
  IN2 w0.094: 112.27,49.15 112.27,50.75 113.18,51.66 113.18,53.62 116.32,56.76 143.06,56.76 143.19,56.89 155.72,56.89 157.07,55.54 158.46,55.54 160.88,53.12 164.62,49.37 174.31,49.37 177.35,52.42 190.58,52.42 193.4,49.6 198.1,49.6 200.52,47.17 200.52,37.06 199.57,36.1 199.57,30.21 202.91,26.86 214.75,26.86 215.22,26.4 216.86,26.4 217.32,26.86 219.45,26.86 219.92,26.4 221.65,26.4 222.11,26.86 229.27,26.86 229.52,26.62 229.99,26.62 v9(230.24,26.87)
  IN3 w0.094: v9(230.24,26.87) 230.37,26.75 231.04,26.75 232.51,25.28 232.51,22.23 237.08,17.66 246.09,17.66 246.66,18.24 247.68,18.24 248.24,17.68 248.24,17.4 248.33,17.3 v8(248.46,17.3)
USB3_TXN2_B0-: length 1.9
  BOTTOM w0.117: U15.18 242.29,23.12 242.44,22.97 243.06,22.97 C362.2
USB3_TXN2_B0-_R: length 36
  IN3 w0.094: v8(244.1,23.22) 244.1,23.22 243.85,22.97 243.71,22.97 243.57,23.11 243.57,25.25 244.11,25.79 244.34,25.79 244.79,26.23 244.79,26.64 244.96,26.8 248.05,26.8 248.41,27.16 252.46,27.16 257.35,32.05 257.35,33.54 258.57,34.75 259.85,34.75 v8(259.93,34.67)
  BOTTOM w0.117: v8(259.93,34.67) 260.03,34.77 262.64,34.77 262.82,34.6 265.31,34.6 265.68,34.23 266.78,34.23 267.18,34.63 267.48,34.63 267.69,34.42 267.86,34.42 268.01,34.57 268.01,34.74 267.76,34.98 267.76,35.21 267.92,35.37 269.63,35.37 CN3.B3
USB3_TXN2_C0-: length 1.9
  BOTTOM w0.117: U15.14 242.29,25.12 242.36,25.05 242.98,25.05 C336.2
USB3_TXN2_C0-_R: length 32.3
  TOP w0.117: CN3.A3 267.2,31.75 267.08,31.63 267.08,31.63 267,31.55 265.01,31.55 263.77,32.79 263.77,33.38 263.14,34.01 262.66,34.01 v4(262.38,34.3)
  IN3 w0.094: v8(259.93,33.87) 259.44,33.87 259.07,34.24 258.61,34.24 257.75,33.38 257.75,31.81 254.89,28.94 254.89,27.92 253.21,26.24 249.77,26.24 247.9,24.37 245.26,24.37 244.47,25.16 244.32,25.16 v8(244.1,25.38)
  BOTTOM w0.117: v4(262.38,34.3) 262.09,34.01 261.89,34.01 261.82,34.08 261.82,34.24 261.71,34.35 261.39,34.35 261.29,34.26 261.29,34.08 261.23,34.01 260.74,34.01 260.5,33.77 260.03,33.77 v8(259.93,33.87)
USB3_TXN2_RE_C2: length 8.6
  IN3 w0.094: v8(235.83,25.89) 235.68,25.89 235.62,25.83 235.62,25.37 234.99,24.75 234.99,24.02 235.41,23.6 236.55,23.6 236.9,23.95 237.32,23.95 237.87,23.41 238.05,23.41 v8(238.12,23.48)
  BOTTOM w0.117: v8(238.12,23.48) 238.26,23.62 U15.4 ; v8(235.83,25.89) 235.83,25.59 235.51,25.27 U14.2
USB3_TXN3: length 164.5
  IN2 w0.094: v3(112.12,47.81) 112.14,47.79 112.85,47.79 112.92,47.86 113.68,48.62 113.68,48.85 114.5,49.67 114.5,53.11 116.69,55.3 128.55,55.3 128.74,55.3 130.03,54.01 136.46,54.01 137.24,54.01 141.64,49.61 144.41,49.61 144.62,49.41 147.25,49.41 149.38,47.28 159.56,47.28 160.42,48.13 174.82,48.13 176.1,49.41 190.89,49.41 191.95,48.36 194.26,48.36 194.68,47.93 196.19,47.93 197.45,46.67 197.45,45.39 197.61,45.23 197.61,37.89 198.29,37.2 198.29,28.28 199.76,26.81 199.76,23.8 205.81,17.76 206.34,17.22 217.36,17.22 217.81,16.76 220.43,16.76 220.89,17.23 225.59,17.23 225.97,17.61 229.56,17.61 229.96,17.22 230.47,17.22 v9(230.63,17.38)
  IN3 w0.094: v9(230.63,17.38) 230.5,17.25 230.37,17.25 230.24,17.38 230.24,21.44 230.5,21.7 230.5,23.1 230.24,23.35 230.24,24.62 230.5,24.87 230.5,25.7 230.6,25.8 230.97,25.8 231.16,25.61 231.16,25.44 231.1,25.38 v8(230.87,25.38)
USB3_TXN3_C: length 1.6
  BOTTOM w0.117: C327.2 231.9,25.64 232.1,25.64 232.46,25.27 U14.10
USB3_TXP2: length 176.4
  IN2 w0.066: v3(111.8,47.64) 111.8,47.81 112.06,48.06 112.06,48.2 112.16,48.3 112.16,48.72 112.49,49.05
  IN2 w0.094: v9(230.24,26.4) 229.42,26.4 229.18,26.64 222.21,26.64 221.74,26.18 219.82,26.18 219.36,26.64 217.42,26.64 216.95,26.18 215.13,26.18 214.66,26.64 202.82,26.64 199.34,30.12 199.34,36.19 200.3,37.15 200.3,47.08 198.01,49.38 193.31,49.38 190.49,52.19 177.44,52.19 174.4,49.15 164.53,49.15 160.72,52.96 158.36,55.32 156.97,55.32 155.63,56.67 143.28,56.67 143.15,56.54 116.41,56.54 113.4,53.53 113.4,51.57 112.49,50.65 112.49,49.05
  IN3 w0.094: v8(247.44,17.3) 247.92,17.3 248.02,17.4 248.02,17.58 247.59,18.02 246.75,18.02 246.18,17.44 236.99,17.44 232.28,22.14 232.28,25.19 230.95,26.52 230.37,26.52 v9(230.24,26.4)
USB3_TXP2_B0+: length 1.9
  BOTTOM w0.117: C372.2 242.98,22.67 242.34,22.67 242.29,22.62 U15.19
USB3_TXP2_B0+_R: length 36
  IN3 w0.094: v8(244.1,22.33) 244.1,22.58 243.92,22.75 243.62,22.75 243.35,23.02 243.35,25.34 244.02,26.01 244.25,26.01 244.57,26.33 244.57,26.73 244.86,27.03 247.96,27.03 248.31,27.38 252.37,27.38 257.13,32.15 257.13,33.63 258.47,34.98 258.88,34.98 v8(258.98,35.07)
  BOTTOM w0.117: v8(258.98,35.07) 262.76,35.07 262.94,34.9 265.43,34.9 265.8,34.53 266.65,34.53 267.79,35.67 269.67,35.67 CN3.B2
USB3_TXP2_C0+: length 1.8
  BOTTOM w0.117: U15.15 242.29,24.62 242.42,24.75 243.06,24.75 C340.2
USB3_TXP2_C0+_R: length 32.3
  TOP w0.117: CN3.A2 264.89,31.25 263.47,32.67 263.47,33.26 263.02,33.71 v4(262.38,33.71)
  IN3 w0.094: v8(258.98,33.47) 259.2,33.69 259.2,33.8 258.98,34.02 258.71,34.02 257.97,33.28 257.97,31.71 255.11,28.85 255.11,27.82 253.3,26.02 249.86,26.02 247.99,24.15 245.17,24.15 244.38,24.94 244.2,24.94 244.1,24.83 v8(244.1,24.49)
  BOTTOM w0.117: v8(258.98,33.47) 260.62,33.47 260.87,33.71 v4(262.38,33.71)
USB3_TXP2_RE_C2: length 8.5
  IN3 w0.094: v8(238.12,23.12) 238.05,23.19 237.77,23.19 237.23,23.73 236.99,23.73 236.64,23.38 235.32,23.38 234.77,23.93 234.77,24.84 235.4,25.47 235.4,25.86 v8(235.32,25.94)
  BOTTOM w0.117: U14.1 235.03,25.67 235.13,25.57 235.39,25.57 235.53,25.72 235.53,25.83 235.43,25.94 v8(235.32,25.94) ; v8(238.12,23.12) U15.3
USB3_TXP3: length 164.5
  IN2 w0.094: v3(112.12,47.4) 112.29,47.57 112.95,47.57 113.08,47.7 113.91,48.53 113.91,48.76 114.08,48.93 114.08,48.93 114.72,49.58 114.72,53.02 116.78,55.08 128.65,55.08 129.94,53.79 136.55,53.79 137.15,53.79 141.55,49.39 144.32,49.39 144.53,49.19 147.16,49.19 149.29,47.06 159.65,47.06 160.51,47.91 174.91,47.91 176.19,49.19 190.8,49.19 191.86,48.14 194.17,48.14 194.59,47.71 196.09,47.71 197.22,46.58 197.22,45.3 197.38,45.14 197.38,37.79 198.07,37.11 198.07,28.19 199.54,26.72 199.54,23.71 205.86,17.39 206.25,17 217.27,17 217.72,16.54 220.52,16.54 220.98,17.01 225.68,17.01 226.06,17.39 229.47,17.39 229.86,17 230.5,17 v9(230.63,16.87)
  IN3 w0.094: v9(230.63,16.87) 230.47,17.03 230.28,17.03 230.02,17.29 230.02,21.54 230.28,21.79 230.28,23 230.02,23.26 230.02,24.71 230.28,24.97 230.28,25.8 230.5,26.02 230.7,26.02 v8(230.87,26.19)
