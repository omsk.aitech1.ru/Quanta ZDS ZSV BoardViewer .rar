# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_BATLOW#: length 5.9
  IN2 w0.064: v9(107.9,36.2) 108.37,36.2 108.86,36.69 109.85,36.69 109.97,36.81 111.14,36.81 111.37,37.04 111.71,37.04 111.95,36.8 v3(112.12,36.8)
  GND2 w0.127: v9(107.9,36.2) 107.9,36.63 v8(107.77,36.76)
  BOTTOM w0.117: v8(107.77,36.76) v4(107.77,36.15)
PM_NBSWON#: length 9.4
  IN2 w0.064: v3(111.48,36.3) 111.38,36.4 110.15,36.4 110.05,36.3 109.04,36.3 107.93,35.19 106.54,35.19 v9(106.32,35.42)
  GND2 w0.117: v9(106.32,35.42) 106.07,35.17 v8(106.07,34.97)
  BOTTOM w0.117: R224.1 105.54,32.85 R216.2 105.85,33.81 106.07,34.03 v8(106.07,34.97) 105.59,34.97 v4(105.53,34.91)
PMIC_INT#: length 49.1
  IN4 w0.071: v8(50.39,11.41) 50.62,11.65 51.14,11.65 52.32,10.46 55.55,10.46 57.02,11.93 57.02,14.1 57.36,14.45 57.36,19.56 57.98,20.17 57.98,21.27 59.21,22.5 59.21,22.89 63.38,27.06 64.38,27.06 69.03,31.71 70.12,31.71 70.56,32.14 70.56,32.75 69.77,33.54 69.77,37.58 v8(71.32,39.13)
  BOTTOM w0.117: R409.2 45.78,12.49 v4(46.07,12.2) 47.1,11.17 48.78,11.17 48.78,11.16 50.14,11.16 v8(50.39,11.41) ; PR161.2 71.52,38.93 v8(71.32,39.13)
PMIC_INT#_R: length 4.8
  TOP w0.064: v2(71.27,42.48) PU5.D12
  GND1 w0.102: v2(71.27,42.48) v9(71.27,41.9)
  GND2 w0.127: v9(71.27,41.9) 71.34,41.83 v8(71.34,41.52)
  BOTTOM w0.117: PR161.1 PR160.1 70.91,39.56 71.39,40.05 71.39,40.78 71.69,41.07 v4(71.69,41.15) 71.34,41.49 v8(71.34,41.52)
PMIC_MBCLK: length 49.5
  TOP w0.089: PU5.J1 68.63,48.34 68.63,48.88 68.22,49.29
  TOP w0.117: v2(66.92,50.59) 67.21,50.59 67.81,49.99 67.81,49.7 68.22,49.29
  GND1 w0.117: v2(66.92,50.59) 66.88,50.63 v9(66.36,50.63)
  GND2 w0.117: v8(65.97,50.42) 66.16,50.42 v9(66.36,50.63)
  IN4 w0.071: v8(50.31,24.77) 50.31,24.87 50.66,25.22 50.66,25.76 51.6,26.69 51.71,26.69 52.1,26.3 52.22,26.3 52.3,26.38 52.3,26.5 51.91,26.89 51.91,27.01 52.19,27.29 v8(52.56,27.29) 52.83,27.01 53.11,27.01 53.19,26.93 53.19,26.6 53.27,26.51 53.39,26.51 53.47,26.6 53.47,26.93 53.56,27.01 53.67,27.01 53.76,26.93 53.76,26.6 53.84,26.51 53.96,26.51 54.04,26.6 54.04,26.93 54.13,27.01 54.24,27.01 54.33,26.93 54.33,26.6 54.41,26.51 54.53,26.51 54.61,26.6 54.61,26.93 54.69,27.01 55.02,27.01 56.52,28.51 57.97,28.51 61.15,31.69 61.15,32.3 61.58,32.73 64.4,32.73 64.79,33.11 64.79,35.21 65.29,35.71 65.29,37.64 64.85,38.08 64.85,42.41 63.6,43.67 63.6,48.93 64.12,49.45 64.57,49.45 65.55,50.42 65.97,50.42 v8(65.97,50.42)
  BOTTOM w0.117: v8(52.56,27.29) Q6067.4 ; v8(65.97,50.42) 65.75,50.2 65.69,50.2 v4(65.35,49.87) 65.02,49.53 64.7,49.21 PR84.2
PMIC_MBCLK_R: length 21.6
  IN4 w0.071: v8(48.18,16.96) 48.65,16.49 51.23,16.49 51.61,16.87 51.61,18.09 51.38,18.32 51.38,22 50.76,22.62 50.76,24.65 v8(50.89,24.77)
  BOTTOM w0.076: 49.52,14.41 49.64,14.29 49.64,13.55 49.64,13.54 49.64,13.26 49.88,13.02 50.87,13.02 51.13,12.76 51.13,12.18 51.39,11.92 U17.E8
  BOTTOM w0.117: v8(50.89,24.77) 50.99,24.87 R353.2 51.81,25.13 52.32,25.13 52.56,24.89 Q6067.3 ; 49.52,14.41 48.33,15.6 48.33,16.81 v8(48.18,16.96)
PMIC_MBSDA: length 49.3
  TOP w0.089: PU5.H1 69.02,49.23 68.35,49.9
  TOP w0.117: v4(67.05,52.36) 66.87,52.19 66.87,51.3 66.97,51.2 PR11.2 67.33,50.92 68.35,49.9
  IN4 w0.071: v4(67.05,52.36) 64.41,49.72 64,49.72 63.32,49.04 63.32,43.56 64.58,42.3 64.58,37.96 65.01,37.53 65.01,35.84 64.51,35.34 64.51,33.23 64.29,33 61.46,33 60.88,32.42 60.88,31.86 57.8,28.79 56.41,28.79 54.91,27.29 v8(53.18,27.29) 52.9,27.56 52.08,27.56 50.31,25.8 v8(50.31,25.66)
  BOTTOM w0.117: v8(53.18,27.29) 53.97,27.29 54.35,26.91 54.35,25.38 53.86,24.89 Q6067.1
PMIC_MBSDA_R: length 18.2
  IN4 w0.071: v8(51.25,16.83) 50.9,17.19 50.9,18.12 51.24,18.46 51.24,21.95 50.63,22.56 50.63,24.86 50.89,25.13 v8(50.89,25.66)
  BOTTOM w0.076: U17.D7 51.89,13.05 52.13,13.29 52.13,14.93
  BOTTOM w0.117: v8(50.89,25.66) 50.99,25.56 R358.2 51.81,25.31 53.47,25.31 53.86,25.7 Q6067.6 ; 52.13,14.93 52.13,14.95 51.25,15.83 v8(51.25,16.83)
PMON: length 134.9
  IN3 w0.203: v4(61.44,22.54) 61.44,23.99 62.58,25.13 65.3,25.13 65.86,25.69 70.9,25.69 71.7,26.49 78.49,26.49 79.44,25.53 84.7,25.53 85.31,24.92 86.89,24.92 88.37,23.45 89.89,23.45 92.7,20.63 92.7,17.61 100.71,9.6 127.78,9.6 128.04,9.86 131.33,9.86 131.61,9.58 139.11,9.58 139.52,9.17 139.52,9.17 139.72,8.97 144.99,8.97 145.14,9.12 147.17,9.12 147.46,8.84 153.86,8.84 160.36,15.33 160.36,18.41 161.42,19.47 165.55,19.47 168.4,16.63 v8(171.06,16.63)
  BOTTOM w0.203: PR286.1 172.44,17.14 172.28,17.3 PR282.1 PC211.2 171.04,16.65 v8(171.06,16.63) ; v4(61.44,22.54) 61.44,22 61.14,21.71 PR249.1 61.14,21.22 61.42,20.94 PC187.2 61.67,20.58 61.85,20.76 PR256.1
POA_AUTH_ERR: length 131.7
  IN3 w0.094: v7(58.67,14.43) 58.67,14.46 57.93,15.19 53.2,15.19 52.98,14.97 52.98,14.26 54.25,12.99 54.25,10.14 53.26,9.15 52.88,9.15 52.57,8.85 49.88,8.85 49.63,9.1 49.63,9.38 v8(49.83,9.58)
  IN4 w0.071: v7(58.67,14.43) 58.77,14.54 63.27,14.54 64.05,13.75 67,13.75 67.44,14.19 71.1,14.19 72.42,15.51 95.49,15.51 100.06,10.94 104.46,10.94 104.92,10.47 137.98,10.47 139.37,11.86 142.79,11.86 143.1,11.55 143.53,11.55 144.03,11.06 144.82,11.06 145.08,11.32 146.17,11.32 146.67,10.82 159.42,10.82 160.52,9.72 162.91,9.72 163.08,9.89 165.3,9.89 v8(166.35,8.83)
  BOTTOM w0.117: CN17.7 v8(166.35,8.83) ; U17.J10 50.16,9.91 v8(49.83,9.58)
POA_EN#: length 132.2
  IN3 w0.094: v8(48.89,9.41) 49.08,9.41 49.81,8.69 53.09,8.69 53.38,8.97 53.38,8.97 54.48,10.07 54.48,13.01 53.18,14.31 53.18,14.55 53.34,14.7 58,14.7 v7(58.34,14.36)
  IN4 w0.071: v7(58.34,14.36) 58.34,14.43 58.58,14.67 63.32,14.67 64.11,13.89 66.94,13.89 67.38,14.33 71.05,14.33 72.36,15.65 95.55,15.65 100.12,11.08 104.52,11.08 104.96,10.63 137.91,10.63 139.3,12.02 143.26,12.02 143.76,11.51 145.75,11.51 145.81,11.45 146.23,11.45 146.72,10.96 158.09,10.96 158.47,11.34 159.12,11.34 160.6,9.86 162.57,9.86 162.76,10.04 165.64,10.04 166.83,8.85 v8(167.28,8.85)
  BOTTOM w0.117: v8(167.28,8.85) 167.35,8.77 CN17.5
POA_FP_PWREN#: length 139.6
  IN3 w0.094: v7(56.33,18.63) 56.49,18.79 60.54,18.79 61.02,18.3 v7(61.13,18.3)
  IN4 w0.071: v8(174.52,14.08) 173.01,12.57 167.03,12.57 166.27,11.8 164.52,11.8 163.27,13.05 154.65,13.05 154.28,12.69 153.66,12.69 153.46,12.9 135.96,12.9 134.26,11.2 105.21,11.2 104.79,11.63 100.35,11.63 94.44,17.53 73.56,17.53 73.21,17.88 69.31,17.88 68.55,17.12 66.83,17.12 66.57,16.87 65.95,16.87 65.33,17.49 65.33,18.28 65.05,18.57 61.39,18.57 v7(61.13,18.3) ; v8(49.39,11.91) 49.39,12.39 49.91,12.91 51.36,12.91 52.09,12.18 55.07,12.18 56.03,13.14 56.03,14.97 56.23,15.17 56.23,18.52 v7(56.33,18.63)
  BOTTOM w0.117: v8(174.52,14.08) v4(174.52,14.69)
POA_POWERREQ: length 136.1
  IN4 w0.071: v8(165.4,8.74) 165.4,8.9 164.92,9.38 162.5,9.38 162.25,9.13 160.19,9.13 158.77,10.55 146.55,10.55 146.2,10.9 145.23,10.9 145.03,10.71 143.5,10.71 142.61,11.59 140.44,11.59 139.05,10.2 99.24,10.2 95.22,14.22 83.62,14.22 83.31,13.92 68.09,13.92 67.52,13.35 62.01,13.35 61.28,14.08 58.9,14.08 58.77,13.95 58.77,13.24 59.18,12.83 59.18,9.57 56.85,7.25 v8(55.72,7.25)
  BOTTOM w0.117: U17.N8 51.08,7.6 50.54,7.6 50.29,7.35 50.29,3.03 50.77,2.55 54.07,2.55 55.72,4.2 v4(55.72,5.95) v8(55.72,7.25) ; v8(165.4,8.74) 165.53,8.74 165.85,8.42 CN17.8
POA_PWR_INT#: length 129.7
  IN3 w0.094: v7(61.82,15.35) 61.82,17.12 60.72,18.22 60.29,18.22 59.68,17.61 56.13,17.61 55.62,18.12 54.71,18.12 54.1,17.51 48.61,17.51 48.26,17.86 v8(48.25,17.86)
  IN4 w0.071: v7(61.82,15.35) 62.1,15.07 63.14,15.07 64.17,14.04 66.88,14.04 67.32,14.48 70.98,14.48 72.3,15.8 95.59,15.8 100.18,11.21 104.57,11.21 105.01,10.78 137.85,10.78 139.35,12.28 146.11,12.28 146.29,12.1 146.29,11.59 146.78,11.1 151.43,11.1 151.87,11.54 159.14,11.54 160.66,10.01 162.43,10.01 162.91,10.5 165.63,10.5 166.85,9.28 v8(167.28,9.28)
  BOTTOM w0.117: v8(167.28,9.28) 166.85,8.85 CN17.6
POWER_ON_LED: length 221.1
  IN3 w0.094: v8(52.7,6.95) 52.79,7.04 53.66,7.04 54.1,6.59 55.79,6.59 56.43,7.23 57.76,7.23 58.64,8.11 58.64,8.67 60.9,10.93 65.17,10.93 67.81,13.57 71.72,13.57 72.52,14.37 79.64,14.37 80.35,13.65 86.89,13.65 87.64,14.4 89.78,14.4 96.5,7.68 98.91,7.68 99.57,7.02 102.34,7.02 102.83,6.53 131.86,6.53 132.1,6.29 139.48,6.29 140.46,7.28 145.67,7.28 145.86,7.47 146.49,7.47 146.77,7.19 158.45,7.19 160.43,5.21 170.94,5.21 171.12,5.02 176.89,5.02 179.89,8.02 179.89,9.69 182.06,11.86 185.18,11.86 186.44,13.12 188.49,13.12 189.22,12.39 194.04,12.39 194.6,12.95 196.89,12.95 201.73,17.79 201.73,24.05 199.35,26.43 199.35,36.19 198.23,37.3 198.23,38.55 196.98,39.8 196.98,42.75 197.53,43.3 197.53,47.52 194.65,50.39 190.26,50.39 v4(189.58,51.07)
  IN4 w0.071: v4(189.58,51.07) 190.33,51.81 190.33,54.05 v4(190.29,54.08) 189.88,54.49 184.98,54.49 184.91,54.42 184.91,54.39 v4(184.61,54.09)
  BOTTOM w0.076: 52.65,7.56 52.65,8.17 U17.M5
  BOTTOM w0.117: 52.65,7.56 52.65,7.23 52.7,7.18 v8(52.7,6.95) ; R154.1 192.22,54.34 191.46,53.58 v4(191.38,53.58) 190.44,53.58 190.29,53.73 v4(190.29,54.08) ; R155.1 v4(184.61,54.09)
PRIM_C0: length 4.1
  BOTTOM w0.117: PR342.2 159.16,24.43 v4(159.33,24.26)
  BOTTOM w0.203: PR236.2 PR227.1 PR342.2 158.74,24.82 159.49,25.58 PU11.4
PRIM_C1: length 4.8
  BOTTOM w0.203: PU11.3 159.91,24.13 159.71,23.92 159.71,23.35 v4(159.35,22.99) 159.35,22.81 PR243.2 158.74,22.02 158.77,21.99 PR251.1 PR341.2
PRIM_LP#: length 2.9
  BOTTOM w0.117: v4(157.65,25.86) 157.63,25.89 PR205.2
  BOTTOM w0.203: PU11.6 159.18,26.58 159.07,26.46 158.65,26.46 ; 158.65,26.46 PR206.2 ; 158.65,26.46 157.63,26.46 PR205.2
PSYS: length 6.4
  IN1 w0.203: v4(172.7,17.59) 173.32,18.22 173.37,18.22 v4(175.08,19.93)
  BOTTOM w0.203: v4(172.7,17.59) PR286.2 ; v4(175.08,19.93) 175.43,19.93 176.52,21.02 PU12.50
PTP_PWR_EN#: length 129.9
  IN3 w0.094: v7(58.13,19.13) 58.24,19.03 60.75,19.03 61.46,18.32 v7(61.72,18.32)
  IN4 w0.071: v8(169.49,12.28) 169.34,12.43 167.09,12.43 166.33,11.67 164.46,11.67 163.21,12.91 154.7,12.91 154.34,12.55 153.61,12.55 153.4,12.76 136.01,12.76 134.32,11.07 105.15,11.07 104.73,11.49 100.29,11.49 94.38,17.39 73.5,17.39 73.15,17.75 69.37,17.75 68.61,16.99 66.88,16.99 66.63,16.73 65.89,16.73 65.2,17.43 65.2,18.22 64.99,18.43 61.83,18.43 v7(61.72,18.32) ; v8(57.96,12.06) 57.96,12.53 58.21,12.78 58.21,13.91 58.08,14.03 58.08,19.08 v7(58.13,19.13)
  BOTTOM w0.076: U17.E2 54.65,12.17 55.81,12.17 55.94,12.04 56.64,12.04 56.64,12.04
  BOTTOM w0.117: 56.64,12.04 56.65,12.06 v8(57.96,12.06) 58.15,12.06 58.54,11.67 v4(58.79,11.67)
PWM_SA: length 62.5
  TOP w0.203: v4(157.31,55.99) PU2.2
  IN1 w0.203: v4(184.53,16.22) 184.07,16.68 182.1,16.68 177.89,20.89 174.82,20.89 172.22,18.29 170.31,18.29 169.97,18.63 169.97,19.82 165.99,23.8 165.99,39.73 162.25,43.46 162.25,52.54 159.24,55.56 157.74,55.56 v4(157.31,55.99)
  BOTTOM w0.203: v4(184.53,16.22) 184.53,16.71 PR299.1
R_SPK+: length 40.7
  IN3 w0.762: v4(236.49,11.54) 235.81,11.54 235.78,11.56 v4(235.71,11.56) 234.72,12.55 231.26,12.55 230.37,11.67 228.01,11.67 227.22,12.45 227.22,13.16 226.69,13.7 224.18,13.7 223.64,13.16 223.64,11.67 222.24,10.27 217.72,10.27 215.92,8.47 215.92,6.18
  BOTTOM w0.508: C382.2 235.25,12.05 235.71,11.59 v4(235.71,11.56) 235.73,11.54 v4(236.49,11.54) 236.62,11.41 v4(238.58,11.41) 241.17,11.41 241.82,10.76 242.18,10.76 ; CN14.1 215.94,5.25 215.27,4.58 215.27,4.08 214.76,3.56 D26.1 ; 243.58,9.74 243.24,10.09 242.86,10.09 242.18,10.76 ; 242.18,10.76 v4(242.18,10.78)
  vias: v7(215.72,5.54) v7(215.72,5.27) v7(215.72,4.99) v7(216.02,5.54) v7(216.02,5.27) v7(216.02,4.99) v7(216.3,5.54) v7(216.3,5.27) v7(216.3,4.99) v8(215.72,5.54) v8(215.72,5.27) v8(215.72,4.99) v8(216.02,5.54) v8(216.02,5.27) v8(216.02,4.99) v8(216.3,5.54) v8(216.3,5.27) v8(216.3,4.99) v10(215.72,5.54) v10(215.72,5.27) v10(215.72,4.99) v10(216.02,5.54) v10(216.02,5.27) v10(216.02,4.99) v10(216.3,5.54) v10(216.3,5.27) v10(216.3,4.99)
R_SPK-: length 35.3
  IN3 w0.762: v4(235.81,10.52) 235.27,10.52 234.9,10.9 v4(234.24,10.9) 233.54,10.19 231.49,10.19 231.06,9.76 223.21,9.76 222.7,9.25 218.21,9.25 216.88,7.93 216.88,5.04
  BOTTOM w0.508: D25.1 214.85,2.62 216.23,4 CN14.2 216.8,4 v8(216.81,4) ; v4(234.24,10.9) 234.27,10.92 C419.2 235.15,10.92 235.54,10.52 v4(235.81,10.52) 236.49,10.52 v4(236.52,10.55) 236.65,10.68 241.01,10.68 242.31,9.38 242.68,9.38
  vias: v7(216.5,4.27) v7(216.5,4) v7(216.5,3.72) v7(216.81,4.27) v7(216.8,3.72) v7(217.09,4.27) v7(217.09,4) v7(217.08,3.72) v8(216.5,4.27) v8(216.5,4) v8(216.5,3.72) v8(216.81,4.27) v8(216.8,3.72) v8(217.09,4.27) v8(217.09,4) v8(217.08,3.72) v10(216.5,4.27) v10(216.5,4) v10(216.5,3.72) v10(216.81,4.27) v10(216.8,3.72) v10(217.09,4.27) v10(217.09,4) v10(217.08,3.72)
REGN6V: length 10.7
  IN2 w0.254: v4(66.01,17.31) 66.01,18.68 v5(70.68,23.36)
  BOTTOM w0.178: PU14.24 69.02,22.48 69.11,22.56 69.53,22.56 70.15,23.18
  BOTTOM w0.203: v4(66.01,17.31) 65.76,17.06 PR288.2
REXT_PS: length 5.3
  BOTTOM w0.117: R363.2 255.38,17.26 v4(255.21,17.43) 255.21,17.76 253.78,19.18 252.57,19.18 252.38,19.38 U13.2
RF_EN: length 202
  TOP w0.117: CN1.56 201.1,37.85 200.78,38.17 200.13,38.17 200.04,38.09 199.38,38.09 v4(199.05,37.76)
  IN3 w0.094: v4(199.05,37.76) 199.67,37.15 199.67,27.76 202.43,25 202.43,17.81 197.09,12.47 194.86,12.47 194.31,11.91 189.03,11.91 188.3,12.64 186.64,12.64 185.36,11.37 182.25,11.37 180.37,9.49 180.37,7.82 177.09,4.54 171.38,4.54 170.96,4.12 160.84,4.12 158.25,6.71 147.84,6.71 147.57,6.43 146.03,6.43 145.66,6.8 140.77,6.8 139.78,5.81 131.9,5.81 131.66,6.05 102.64,6.05 102.15,6.54 99.36,6.54 98.7,7.2 96.03,7.2 90.09,13.14 80.16,13.14 79.41,13.89 72.72,13.89 71.92,13.09 68.01,13.09 62.65,7.74 61.03,7.74 61.03,7.74 60.73,7.74 60.72,7.74 v8(59.94,7.74)
  BOTTOM w0.117: R462.1 48.13,5.82 48.81,5.14 48.81,2.88 49.32,2.37 54.17,2.37 56.05,4.25 56.05,5.42 56.74,6.1 59.23,6.1 v4(59.65,6.53) 59.94,6.82 v8(59.94,7.74)
RING2: length 1.4
  BOTTOM w0.203: U19.17 251.6,9.07 252.04,9.51 v4(252.24,9.51)
  vias: v4(252.88,9.48) v4(256.79,9.74) v4(257.17,10.47) v4(257.58,9.74)
RING2_R: length 11.1
  IN3 w1.016: 270.55,13.2 263.3,13.2 261.27,11.17 v4(260.29,11.17)
  vias: v4(259.4,11.17)
RSMRST#_PWRGD: length 40.2
  GND1 w0.102: v9(68.82,42.85) 68.82,42.88 68.52,43.18 v2(68.52,43.23)
  GND2 w0.127: v9(68.82,42.85) 68.8,42.85 68.71,42.76 68.22,42.76 v7(68.19,42.74)
  IN4 w0.071: v7(68.19,42.74) 68.19,41.39 v8(68.5,41.08) 68.45,41.03 68.45,39.82 67.78,39.15 67.78,33.91 66.87,33 66.87,32.32 65.22,30.67 64.71,30.67 63.54,29.5 63.04,29.5 57.49,23.94 57.49,22.93 55.62,21.06 55.62,16.06 55.44,15.87 55.44,13.33 55.02,12.91 v8(54.39,12.91)
  BOTTOM w0.117: PR159.1 69.21,39.61 69.31,39.72 69.31,40.58 68.81,41.08 v8(68.5,41.08)
RSVD_BB14: length 6.9
  TOP w0.117: v3(105.94,37.07) 105.79,37.22 R105.2
  IN2 w0.064: 108.38,36.98 108.82,37.41 109.2,37.41 109.27,37.34 110.21,37.34 110.49,37.61 111.16,37.61 v3(111.48,37.29)
  IN2 w0.074: 108.38,36.98 106.03,36.98 v3(105.94,37.07)
RSVD_L20: length 1
  GND1 w0.127: v9(114.01,46.77) 113.93,46.86 113.61,46.86 113.57,46.9 v2(113.41,46.9)
  GND2 w0.127: v9(114.01,46.77) 114.1,46.85 114.1,47.12 v8(114.09,47.12)
RTC_RST#: length 39.6
  TOP w0.06: U3.BN12 111.16,34.33 110.5,33.67 110.36,33.67
  TOP w0.089: v1(106.99,34.03) 107.35,33.67 110.36,33.67
  TOP w0.117: R95.2 94.74,39.3 95.1,38.94 95.1,37.87 CL1_CL1.2 96.57,36.39 96.57,34.57 C24.1 v4(97.78,34.17) 97.91,34.04 97.91,33.08 97.96,33.03 97.96,32.76 99.47,31.25 99.47,30.88 99.62,30.73 99.62,28.77 v2(99.59,28.73)
  IN1 w0.06: v1(106.99,34.03) 106.59,34.03 106.11,33.55
  IN1 w0.071: v2(99.59,28.73) 100.05,29.2 100.05,30.1 100.42,30.47 103.11,30.47 104.97,32.33 104.97,32.93 105.32,33.28 105.84,33.28 106.11,33.55
  GND1 w0.117: v9(99.1,28.28) 99.13,28.28 v2(99.59,28.73)
  GND2 w0.117: v8(98.5,28.33) 99.05,28.33 v9(99.1,28.28)
  BOTTOM w0.117: Q15.3 92.68,25.94 92.83,25.79 94.02,25.79 94.78,26.55 96.78,26.55 97.22,26.11 97.93,26.11 98.39,26.58 98.39,28.23 v8(98.5,28.33) 98.04,28.33 C281.1
RTC_X1: length 13.6
  TOP w0.117: Y2.2 102.15,33.35 C32.1 102.84,33.32 v3(103.75,33.32)
  IN1 w0.06: v11(113.09,34.58) 112.73,34.58 112.53,34.38 112.52,34.38 110.36,32.21 109.08,32.21
  IN1 w0.071: 109.08,32.21 v3(106.88,32.21)
  IN2 w0.094: v3(103.75,33.32) 103.95,33.13 104.41,33.13 105.02,32.52 106.57,32.52 v3(106.88,32.21)
RTC_X2: length 13.3
  TOP w0.117: v3(103.75,32.54) 102.96,32.54 C27.1 101.98,32.4 Y2.1
  IN1 w0.06: 108.8,31.94 109.09,31.94 109.14,31.99 110.33,31.99 112.65,34.31 v11(112.77,34.31)
  IN1 w0.071: 108.8,31.94 106.7,31.94 v3(106.62,32.01)
  IN2 w0.094: v3(103.75,32.54) 104.03,32.82 104.29,32.82 104.92,32.19 106.45,32.19 v3(106.62,32.01)
RXD: length 2.6
  BOTTOM w0.117: U20.F2 151.31,4.54 151.31,3.25 151.02,2.96 T68.1
SA0: length 2.3
  TOP w0.117: R100.1 R101.1 84.42,37.65 84.4,37.62 v4(84.4,37.34) U5.7
SATA_DEVSLP1: length 104.8
  TOP w0.117: v4(43.13,41.7) v4(42.49,41.7) R73.2 ; R32.1 108.28,52.49 108.25,52.46 R10969.1
  IN1 w0.071: v3(108.68,52.48) 107.97,53.19 98.93,53.19 98.16,52.43 98.16,51.41 96.27,49.51 96.27,44.65 95.74,44.12 95.74,42.12 94.07,40.45 94.07,36.06 93.83,35.82 93.83,35.43 91.78,33.37 91.49,33.37 90.18,32.07 88.79,32.07 88.32,32.53 87.92,32.53 83.32,27.92 68.15,27.92 67.58,27.35 64.25,27.35 63.66,26.77 59.18,26.77 58.44,26.02 57.88,26.02 50.27,26.02 v3(50.01,25.76)
  IN2 w0.094: v3(50.01,25.76) 50.01,27.06 45.56,31.5 45.56,34.37 42.62,37.32 42.62,41.18 v4(43.13,41.7) ; v3(108.68,52.48) 108.68,51.45 109.38,50.75 109.97,50.75 110.51,50.21 v3(110.51,48.12)
SATA_RXN: length 110.5
  IN1 w0.071: v1(115.34,48.87) 115.53,48.87 115.82,49.16 115.82,51.03 114.73,52.13 114.73,53.56 113.35,54.93 98.96,54.93 95.67,51.63 95.67,50.97 95.12,50.41 95.12,45.17 93.45,43.49 92.86,43.49 91.16,41.8 88.55,41.8 84.45,37.7 84.45,34.85 80.34,30.75 75.07,30.75 74.19,31.63 71.47,31.63 71.06,31.22 68.77,31.22 66.68,29.13 63.44,29.13 63.01,28.71 56.48,28.71 55.75,27.98 55.23,27.98 50.92,27.98 50.37,28.53 48.33,28.53 47.62,29.24 47.17,29.24 v4(47.04,29.38)
  BOTTOM w0.117: v4(47.04,29.38) 46.95,29.29 46.38,29.29 45.37,30.3 45.37,31.67 44.54,32.5 42.51,32.5 40.13,34.88 40.13,40.17 41.39,41.44 41.39,42.13 41.06,42.46 40.54,42.46 C149.2
SATA_RXN_C: length 3.1
  BOTTOM w0.117: C149.1 38.73,42.74 38.07,43.4 36.65,43.4 CN2.43
SATA_RXP: length 110.5
  IN1 w0.071: v4(47.06,28.72) 47.06,28.89 47.24,29.06 47.54,29.06 48.26,28.35 50.29,28.35 50.84,27.8 55.15,27.8 55.82,27.8 56.55,28.53 63.09,28.53 63.51,28.95 66.76,28.95 68.84,31.04 71.13,31.04 71.54,31.45 74.11,31.45 75,30.57 80.42,30.57 84.63,34.78 84.63,37.63 88.62,41.62 91.23,41.62 92.93,43.32 93.52,43.32 95.29,45.09 95.29,50.34 95.85,50.89 95.85,51.56 99.04,54.75 113.28,54.75 114.55,53.48 114.55,52.05 115.64,50.96 115.64,49.24 115.53,49.12 115.32,49.12 115.26,49.19 115.26,49.31 v1(115.34,49.39)
  BOTTOM w0.117: C160.2 40.57,42.16 40.93,42.16 41.09,42 41.09,41.56 39.83,40.3 39.83,34.76 42.39,32.2 44.42,32.2 45.07,31.55 45.07,30.17 46.26,28.99 46.79,28.99 v4(47.06,28.72)
SATA_RXP_C: length 3.1
  BOTTOM w0.117: CN2.41 37.63,43.09 37.95,43.09 38.67,42.37 39.56,42.37 39.64,42.28 39.64,42.01 C160.1
SATA_TXN: length 114.4
  IN1 w0.071: v4(47.9,28.14) 48.06,27.98 50.14,27.98 50.86,27.25 57.93,27.25 58.83,28.15 63.27,28.15 63.69,28.58 66.92,28.58 69.01,30.66 72.54,30.66 73.05,30.15 80.54,30.15 85,34.62 85,37.44 88.8,41.24 91.39,41.24 93.09,42.94 93.77,42.94 95.68,44.85 95.68,50.19 96.22,50.74 96.22,51.4 99.13,54.32 113.18,54.32 113.96,53.54 113.96,51.87 114.98,50.86 114.98,49.06 114.46,48.55 114.46,47.93 114.77,47.62 115.27,47.62 115.34,47.7 v1(115.34,47.94)
  BOTTOM w0.117: C134.2 40.16,43.73 40.16,44.05 40.29,44.18 40.63,44.18 41.9,42.91 41.9,41.35 41.09,40.54 41.09,37.04 v4(40.61,36.56) 41.1,36.07 41.1,34.61 42.78,32.92 44.82,32.92 48.49,29.25 48.49,28.15 48.25,27.91 48.13,27.91 v4(47.9,28.14)
SATA_TXN_C: length 3.2
  BOTTOM w0.117: CN2.47 36.65,44.4 38.09,44.4 38.78,43.71 39.4,43.71 C134.1
SATA_TXP: length 114.5
  IN1 w0.071: v1(115.34,47.39) 115.29,47.44 114.69,47.44 114.29,47.85 114.29,48.62 114.8,49.14 114.8,50.78 113.79,51.8 113.79,53.46 113.11,54.14 99.21,54.14 96.4,51.33 96.4,50.66 95.85,50.12 95.85,44.77 93.84,42.76 93.16,42.76 91.46,41.06 88.88,41.06 85.18,37.37 85.18,34.55 80.61,29.98 72.97,29.98 72.46,30.49 69.08,30.49 66.99,28.4 63.77,28.4 63.34,27.97 58.9,27.97 58,27.07 50.79,27.07 50.06,27.8 48.22,27.8 v4(47.93,27.5)
  BOTTOM w0.117: v4(47.93,27.5) 48.03,27.61 48.37,27.61 48.79,28.03 48.79,29.37 44.94,33.22 42.91,33.22 41.4,34.73 41.4,36.08 v4(41.88,36.56) 41.39,37.04 41.39,40.42 42.2,41.23 42.2,43.03 40.76,44.48 40.43,44.48 C114.2
SATA_TXP_C: length 3.2
  BOTTOM w0.117: C114.1 39.62,44.51 39.62,44.14 39.49,44.01 38.91,44.01 38.2,44.71 37.63,44.71 CN2.49
SCLK: length 4.4
  BOTTOM w0.117: PU12.38 181.41,22.46 182.77,21.1 182.77,20.08 v4(182.98,19.87) 183.3,19.55 PR269.1
SD_RCOMP: length 5.8
  TOP w0.305: U3.BF1 107.68,36.37 106.37,37.69 106.37,38.71 105.97,39.11 105.97,39.79 105.46,40.29 R84.1
SDIO: length 4
  BOTTOM w0.117: PR254.2 184.14,21.21 183.84,21.21 v4(182.08,22.97) 182.01,23.05 181.84,23.05 181.63,23.26 PU12.36
SENSEA: length 4.9
  BOTTOM w0.203: U19.13 251.83,10.67
  BOTTOM w0.254: 251.83,10.67 251.86,10.71 R418.2 v4(252.77,11.71) 252.57,11.9 R395.2
SENSOR_HUB_INT1#: length 120.3
  TOP w0.102: R10968.1 104.53,41.34 105.48,41.34 v1(105.51,41.32) ; R78.1 105.15,40.77 105.25,40.67 105.61,40.67 106.23,40.05 106.23,39.22 106.63,38.82 106.63,37.83 107.76,36.7 U3.BD2
  TOP w0.117: R78.1 105.33,41.04 105.51,41.22 v1(105.51,41.32)
  IN1 w0.071: v1(105.51,41.32) 105.3,41.11 101.32,41.11 100.02,39.81 99.87,39.81 98.62,38.56 98.62,37.78 97.45,36.61 97.45,34.63 97.31,34.49 97.31,30.49 96.21,29.4 96.21,28.05 96.11,27.94 96.11,24.95 97.91,23.15 97.91,14.16 99.59,12.48 100.21,12.48 102.36,10.33 105.04,10.33 105.88,9.49 135.07,9.49 136.67,7.88 156.51,7.88 157.27,7.12 158.37,7.12 159.25,8.01 162.3,8.01 v3(162.4,8.11)
  IN2 w0.094: v9(162.48,8.44) 162.4,8.36 v3(162.4,8.11)
  IN3 w0.094: v8(161.84,12.02) 162.48,11.39 v9(162.48,8.44)
  BOTTOM w0.117: R391.2 161.5,16.08 162.38,15.2 Q27.3 162.38,14.16 161.69,13.47 v4(161.69,12.55) 161.69,12.17 v8(161.84,12.02)
SENSOR_HUB_INT1#_Q: length 17.4
  IN3 w0.094: v8(156.51,8.95) 156.92,9.35 158.39,9.35 160.88,11.84 v8(160.88,12.17)
  BOTTOM w0.117: R391.1 160.97,16.87 160.57,16.87 R390.1 160.47,16.44 160.34,16.31 Q27.1 160.34,15.17 161.28,14.23 161.28,12.63 160.88,12.22 v8(160.88,12.17) ; v8(156.51,8.95) 155.26,8.95 v4(155.06,8.74) 154.86,8.95 152.7,8.95 152.32,8.57 152.32,8.04 U20.E8
SERIRQ: length 77
  TOP w0.117: R10974.2 104.32,34.4 103.65,34.4 103.42,34.63 103.42,34.93 R119.2 103.12,34.84 103.12,34.68 v3(103.07,34.63)
  IN1 w0.071: v11(110.01,34.74) 109.8,34.53 109.4,34.53 109.27,34.67 107.91,34.67 107.17,35.41 106.12,35.41 105.78,35.06 104.08,35.06 103.67,34.65 103.09,34.65 v3(103.07,34.63)
  IN2 w0.094: v3(103.07,34.63) 102.73,34.98 101.14,34.98 101.06,34.89 100.81,34.89 100.75,34.83 100.45,34.83 100.1,34.47 100.1,34.32 98.45,32.68 98.45,31.97 96.5,30.02 95.8,30.02 92.55,26.78 92.55,23.18 91.54,22.16 91.54,18.4 89.12,15.98 86.84,15.98 85.73,14.87 81.55,14.87 81.37,15.05 73.67,15.05 72.4,13.77 63.78,13.77 63.57,13.56 62.69,13.56 62.13,14.13 59.09,14.13 57.91,12.94 57.91,10.28 v4(58.03,10.15)
  BOTTOM w0.076: U17.G2 54.43,10.91 54.68,11.17 55.56,11.17 55.77,10.95 56.64,10.95
  BOTTOM w0.117: v4(58.03,10.15) 57.88,10.3 57.88,10.51 57.43,10.95 56.64,10.95
SHUTDOWN#: length 179.1
  TOP w0.064: v2(71.75,45) PU5.C7
  TOP w0.117: Q2.3 97.51,58.48 v4(98.39,59.37) ; v3(156.56,46.39) 156.76,46.18 159.05,46.18 160.16,45.08 PU4.3 ; v3(150.06,46.62) 150.06,47.11 148.37,48.8 141.48,48.8 137.23,53.05 137.23,55.2 136.47,55.96 130.98,55.96 130.73,55.71 v4(130.73,55.3)
  GND1 w0.127: v9(71.8,45.48) 71.75,45.43 v2(71.75,45)
  IN2 w0.094: v3(156.56,46.39) 156.33,46.62 v3(150.06,46.62)
  IN3 w0.094: v7(64.79,29.06) 65.58,29.06 66.03,29.52 67.96,29.52 69.13,30.69 71.24,30.69 71.92,30.01 83.23,30.01 83.36,29.89 v8(87.35,29.89)
  GND2 w0.127: v9(71.8,45.48) 71.8,45.3 71.99,45.11 v8(71.99,44.83)
  IN4 w0.071: v8(55.34,10.91) 55.37,10.91 55.92,11.47 55.92,12.47 56.29,12.83 56.29,14.46 56.64,14.82 56.64,20.96 58.49,22.81 58.49,23.47 63.1,28.07 63.8,28.07 v7(64.79,29.06) 65.35,29.06 68.29,32.01 68.29,32.69 69.03,33.43 69.03,38.07 70.74,39.78 70.74,41.38 71.9,42.54 71.9,42.81 71.8,42.92 71.8,44.64 v8(71.99,44.83) ; v4(130.73,55.3) 126.1,59.93 100.02,59.93 99.26,59.16 98.6,59.16 v4(98.39,59.37)
  BOTTOM w0.076: v8(55.34,10.91) 55.34,10.91 U17.G1
  BOTTOM w0.117: v4(98.39,59.37) 98.39,58.3 98.93,57.77 98.93,56.01 96.67,53.75 96.67,50.71 95.09,49.13 95.09,45.57 92.9,43.39 v4(88.78,43.39) 85.25,39.86 85.25,34.28 87.37,32.15 R230.1 87.37,29.91 v8(87.35,29.89)
SIO_EXT_SCI#: length 88.2
  TOP w0.117: v1(106.55,52.56) 106.55,52.58 106.17,52.96 ; R31.2 106.52,52.95 106.5,52.96 106.17,52.96 ; 106.17,52.96 R29.2
  IN1 w0.071: v1(106.55,52.56) 106.01,52.56 105.52,53.04 98.97,53.04 98.3,52.38 98.3,51.35 96.4,49.45 96.4,44.59 95.87,44.06 95.87,42.06 94.21,40.39 94.21,36 93.97,35.77 93.97,35.37 91.84,33.24 91.54,33.24 90.24,31.93 88.73,31.93 88.27,32.39 87.98,32.39 83.24,27.66 72.5,27.66 71.18,26.34 65.04,26.34 64.43,25.74 59.81,25.74 v3(58.67,24.59)
  IN2 w0.094: v9(53.77,7.91) 53.77,9.07 54.39,9.69 54.39,15.08 57.91,18.6 57.91,23.83 v3(58.67,24.59)
  GND2 w0.127: v8(53.39,7.91) v9(53.77,7.91)
SIO_EXT_SCI#_R: length 5.7
  TOP w0.102: 108.16,50.71 108.55,50.31 108.55,49.77 v3(108.45,49.67)
  TOP w0.117: R31.1 106.98,52.42 106.98,52.42 106.98,51.88 108.16,50.71
  IN2 w0.094: v3(108.45,49.67) 108.45,49.49 108.78,49.16 108.78,48.88 109.09,48.58 109.27,48.58 109.6,48.24 v3(109.6,48.1)
SIO_EXT_SMI#: length 82.3
  TOP w0.117: R43.2 104.64,50.49 104.6,50.54 R38.2 104.13,50.99 v1(104.08,51.04)
  IN1 w0.071: v1(104.08,51.04) 98.19,51.04 96.54,49.4 96.54,44.53 96.01,44.01 96.01,42 94.34,40.33 94.34,35.95 94.11,35.71 94.11,35.31 91.89,33.1 91.6,33.1 90.29,31.79 88.56,31.79 88.47,31.88 87.67,31.88 83.3,27.52 72.56,27.52 71.24,26.2 65.34,26.2 64.63,25.49 59.92,25.49 v3(59.2,24.77)
  IN2 w0.094: v3(59.2,24.77) 58.41,23.98 58.41,18.65 54.64,14.88 54.64,9.08 v9(54.81,8.91)
  GND2 w0.127: v8(54.39,8.91) v9(54.81,8.91)
SIO_EXT_SMI#_R: length 6.6
  TOP w0.089: v1(107.74,47.46) 107.74,48.17 106.88,49.04
  TOP w0.117: 106.88,49.04 105.79,50.12 R43.1
  IN1 w0.071: v11(109.85,46.69) 109.64,46.69 109.62,46.71 109.4,46.71 109.01,47.1 108.66,47.1 108.33,47.44 107.77,47.44 v1(107.74,47.46)
SKTOCC#: length 1.9
  TOP w0.06: v4(126.79,49.9) 126.79,49.87 126.69,49.76 126.69,49.18 126.48,48.97 U3.B62
  BOTTOM w0.117: v4(126.79,49.9) 126.46,49.57 T40.1
SLEEVE: length 1.2
  BOTTOM w0.203: U19.18 252.09,8.67 v4(252.19,8.78)
  vias: v4(252.85,8.77) v4(256.84,7.41) v4(257.14,8.11) v4(257.75,7.43)
SLEEVE_R: length 37.9
  IN1 w0.508: 260.13,7.36 260.13,6.14 261.06,5.21 261.06,2.57 261.54,2.09 266.11,2.09 266.8,2.78 268.78,2.78 269.45,2.1 271.76,2.1 272.81,3.15 CN5.1
  IN2 w0.508: 260.13,7.36 260.13,6.14 261.06,5.21 261.06,2.57 261.54,2.09 266.11,2.09 266.8,2.78 268.78,2.78 269.45,2.1 271.76,2.1 272.81,3.15 CN5.1
  vias: v4(258.79,8.97) v4(260.01,8.85) v4(260.73,8.85)
SLP_A#: length 2.2
  GND1 w0.127: v2(112.45,36.55) 112.45,36.82 112.46,36.84 112.46,36.86 112.52,36.91 v9(112.52,36.94)
  GND2 w0.127: v9(112.52,36.94) 112.29,36.72 v8(111.91,36.72)
  BOTTOM w0.117: v8(111.91,36.72) 111.56,36.72 T49.1
SLP_S0#: length 245.2
  TOP w0.117: v4(87.27,54.24) 87.06,54.03 PR62.2 ; PR40.1 v4(48.25,41.51) 47.75,41.51 v4(47.42,41.84)
  IN2 w0.066: v3(110.29,37.04) 109.97,37.04 109.81,37.21 109.22,37.21 109.14,37.28 108.88,37.28 108.44,36.85 105.42,36.85 105.04,37.23 105.04,37.56 104.79,37.8 104.59,37.8 104.46,37.93 102.48,37.93 101.95,38.46 99.71,38.46 99.33,38.09 99.13,38.09
  IN2 w0.094: v9(65.25,29.43) 65.53,29.14 66.14,29.14 66.56,28.72 76.19,28.72 77.51,27.39 84.8,27.39 87.85,30.44 v9(88.11,30.44) 89.2,30.44 90.23,31.47 92.19,31.47 92.42,31.7 92.83,31.7 96.7,35.56 96.7,36.36 97.77,37.44 98.28,37.44 98.93,38.09 99.13,38.09
  IN3 w0.094: v7(68.5,34.07) 68.47,34.04 67.56,34.04 67.18,33.66 66.68,33.66 65.7,32.68 57.88,32.68 57.78,32.78 57.78,32.81 55.6,34.99 53.09,34.99 52.19,34.09 49.9,34.09 49.63,34.37 49.63,35.15 48.85,35.93 48.85,38.92 47.42,40.35 v4(47.42,41.84) ; v4(87.27,54.24) 87.64,53.87 88.53,53.87 90.99,51.41 90.99,47.94 v8(91.51,47.43) ; v4(158.24,27.36) 158.59,27.01 158.59,21.83 157.73,20.96 157.73,20.1 155.77,18.14 155.77,13.77 153.55,11.55 140.31,11.55 140.31,11.56 140.13,11.74 132.55,11.74 132.27,12.02 127.04,12.02 126.76,11.74 107.95,11.74 107.89,11.8 107.65,12.05 107.4,12.3 107.09,12.3 106.53,11.74 102.56,11.74 95.14,19.16 95.14,22.19 93.44,23.88 v7(93.44,24.42)
  GND2 w0.117: v7(87.6,30.39) 87.64,30.44 v9(88.11,30.44) ; v8(65.2,29.9) 65.2,29.48 v9(65.25,29.43)
  IN4 w0.071: v4(87.27,54.24) 86.6,54.9 85.52,54.9 85.17,55.25 81.98,55.25 77.03,50.3 75.1,50.3 73.65,48.85 72.97,48.85 72.77,48.65 72.77,48.42 72.82,48.36 72.82,47.66 71.42,46.26 71.42,43.55 70.92,43.05 v8(70.88,43.05) 70.88,42.81 70.28,42.2 70.28,40.75 69.95,40.42 69.95,39.69 68.5,38.24 68.5,34.07 v7(68.5,34.07) 68.5,33.61 67.56,32.67 67.56,32.01 65.45,29.9 v8(65.2,29.9) ; v7(93.44,24.42) 90.6,24.42 90.19,24.82 90.19,27.26 90,27.45 90,28.77 89.71,29.06 88.24,29.06 87.73,29.58 87.73,30.26 v7(87.6,30.39)
  BOTTOM w0.117: PR111.1 91.68,46.94 91.51,47.12 v8(91.51,47.43) ; v4(158.24,27.36) 158.64,26.96 PR206.1 ; PR210.2 73.02,26.61 72.87,26.76 72.16,26.76 71.92,27.01 71.47,27.01 v4(70.41,28.07) 69.76,28.72 65.95,28.72 65.42,29.24 65.42,29.67 v8(65.2,29.9)
SLP_S3#: length 309.2
  IN1 w0.071: v1(86.3,52.48) 87.98,52.48 89.22,51.24 v4(90.57,51.24) ; v3(132.58,5.57) 132.41,5.74 121.99,5.74 121.72,6.01 105.69,6.01 104.85,6.84 v3(103.37,6.84)
  IN2 w0.064: v3(111.61,37.89) 110.6,37.89 110.41,38.08 109.5,38.08 109.16,37.75 108.78,37.75 108.33,37.3 106.51,37.3 105.53,38.29
  IN2 w0.066: 105.53,38.29 102.77,38.29 102.29,38.77 100.53,38.77
  IN2 w0.094: v3(103.37,6.84) 103.12,6.59 100.27,6.59 95.23,11.63 87.1,11.63 86.41,12.32 80.31,12.32 79.33,13.3 74.38,13.3 73.12,12.04 67.75,12.04 66.01,10.29 60.83,10.29 v4(59.94,9.41) ; v4(175.51,11.23) 175.29,11.45 171.82,11.45 171.07,10.7 163.82,10.7 161.66,8.54 154.95,8.54 153.14,6.74 152.85,6.74 151.94,5.82 151.94,5.01 151.53,4.6 146.86,4.6 146.15,5.32 140.61,5.32 140.15,5.77 134.36,5.77 133.93,6.2 133.22,6.2 v3(132.58,5.57) ; 100.53,38.77 100.39,38.91 97.37,38.91 95.12,36.66 95.12,36.13 91.81,32.82 90.24,32.82 88.81,31.39 87.46,31.39 84.93,28.86 77.38,28.86 76.58,29.67 72.53,29.67 71.27,30.93 67.33,30.93 v9(66.64,30.24)
  IN3 w0.094: 69.23,34.27 69.37,34.14 v8(72.23,34.14) 74.15,34.14 75.28,35.26 75.28,36.46 78.01,39.19 81.59,39.19 83.55,41.16 83.55,42.43 85.44,44.32 85.71,44.32 86.22,44.83 87.56,44.83 88.28,45.55 91.03,45.55 91.54,46.06 91.54,46.79 90.57,47.76 v4(90.57,51.24) ; 69.23,34.27 69.15,34.35 67.26,34.35 66.91,34 66.6,34 65.58,32.98 58.16,32.98 55.85,35.29 52.47,35.29 52.17,34.98 50.21,34.98 49.14,36.05 49.14,39.1 47.9,40.34 v8(47.9,41.82) ; 69.23,34.27 v7(69.26,34.27)
  GND2 w0.117: v7(66.53,29.91) 66.64,30.03 v9(66.64,30.24)
  IN4 w0.071: v8(72.64,43.44) 72.69,43.39 72.69,42.09 71.83,41.23 71.18,41.23 v8(70.99,41.04) 70.99,39.71 69.26,37.98 v7(69.26,34.27) 69.26,33.21 68.58,32.53 68.58,31.96 v7(66.53,29.91) 64.44,27.82 63.43,27.82 58.71,23.1 58.71,22.72 56.87,20.87 56.87,14.72 56.51,14.37 56.51,12.69 v8(56.15,12.33)
  BOTTOM w0.117: v8(72.23,34.14) 72.23,33.97 71.57,33.31 71.57,32.6 v4(71.91,32.25) 72.26,31.91 72.26,28.81 71.6,28.15 PR198.2 ; v8(70.99,41.04) 70.9,41.13 v4(70.4,41.13) 70.34,41.07 69.96,41.07 69.31,41.71 69.31,42.27 69.54,42.49 PR134.1 ; U17.D1 55.81,12.41 55.89,12.33 v8(56.15,12.33) 57.43,12.33 57.44,12.34 57.69,12.34 57.93,12.58 C376.1 58.21,12.58 58.63,12.16 59.69,12.16 59.94,11.91 v4(59.94,11.08) v4(59.94,9.41) ; v4(175.51,11.23) PR493.2 ; PR127.1 74.82,43.92 74.63,43.73 73.43,43.73 73.14,43.44 v8(72.64,43.44) ; PR129.1 50.7,42.53 49.83,42.53 49.12,41.82 v8(47.9,41.82)
SLP_S4#: length 264.2
  TOP w0.117: PR14.1 70.5,51.93 v4(70.73,52.16)
  IN2 w0.064: 105.8,35.49 106.24,35.05 107.99,35.05 109.12,36.18 110.11,36.18 110.19,36.26 111.2,36.26 111.39,36.08 111.56,36.08 111.79,36.3 112.03,36.3
  IN2 w0.066: 99.21,37.61 101.69,37.61 102.1,37.19 104.1,37.19 105.8,35.49
  IN2 w0.074: v3(112.12,36.3) 112.03,36.3
  IN2 w0.094: v9(54.89,7.28) 55.24,7.63 55.24,9.16 54.89,9.51 54.89,14.78 58.92,18.81 58.92,23.6 63.06,27.74 v9(65.73,27.74) 71.03,27.74 71.47,27.3 76.22,27.3 77.18,26.34 84.89,26.34 v9(85.08,26.14) 85.26,26.32 86.59,26.32 91,30.73 92.56,30.73 97.19,35.36 97.19,36.01 97.34,36.16 97.98,36.79 97.98,36.8 98.19,37.02 98.61,37.02 99.21,37.61 ; v4(70.73,52.16) 71.65,51.25 71.65,50.18 v9(72.59,49.24)
  IN3 w0.094: v9(85.08,26.14) 85.39,26.14 v7(85.49,26.04) ; v7(168.8,12.94) 168.8,9.38 171.6,6.59 174.31,6.59 v8(174.36,6.54)
  GND2 w0.117: v9(72.59,49.24) 73.04,48.78 v7(73.04,48.61) ; v9(54.89,7.28) 55.11,7.5 v8(55.11,7.53) ; v9(65.73,27.74) 65.96,27.97 v7(65.96,28.05)
  IN4 w0.071: v8(81.17,55.7) 76.73,51.26 73.89,51.26 73.43,50.81 72.95,50.81 71.87,51.89 71,51.89 v4(70.73,52.16) ; v7(85.49,26.04) 85.49,25.84 92.81,18.52 97.17,18.52 98.93,16.77 98.93,13.36 100.44,11.85 104.88,11.85 105.3,11.43 134.17,11.43 135.86,13.12 153.64,13.12 153.85,12.91 154.19,12.91 154.82,13.54 160.07,13.54 160.34,13.27 161.62,13.27 162.2,13.85 163.11,13.85 164.03,12.94 v7(168.8,12.94) ; v7(73.04,48.61) 73.1,48.55 73.1,47.33 72.26,46.49 72.26,44.82 73.65,43.42 73.65,42.43 v8(73.95,42.13) 73.95,40.19 71.14,37.38 71.14,33.84 v8(72,32.98) 72,32.77 70.58,31.35 69.3,31.35 66,28.05 v7(65.96,28.05)
  BOTTOM w0.117: v8(174.36,6.54) 174.34,6.51 174.34,6.28 174.09,6.03 U39.10 ; PR199.2 73.04,31.94 v8(72,32.98) ; C441.1 57.65,7.07 57.52,6.94 v4(56.64,6.94) 56.41,6.94 55.82,7.53 v8(55.11,7.53) 54.89,7.75 U17.N1 ; v8(81.17,55.7) 81.17,53.96 81.81,53.32 84.07,53.32 84.38,53.64 PR64.1 84.6,53.45 84.78,53.27 85.42,53.27 86.46,52.23 90.75,52.23 92.23,50.75 92.23,47.89 v4(92.2,47.86) ; v4(92.2,47.86) PR98.1 ; v4(92.2,47.86) 92.23,47.84 92.23,45.74 91.41,44.91 91.09,44.91 PR114.1
SLP_S5#: length 3
  IN1 w0.071: v1(111.4,35.81) 111.4,35.99 110.93,36.46 110.93,36.54 v2(110.58,36.89)
  GND1 w0.06: v9(110.61,37.29) 110.61,37.24 110.58,37.22 v2(110.58,36.89)
  GND2 w0.127: v9(110.61,37.29) 110.61,36.87 110.61,36.87 v8(110.61,36.82)
  BOTTOM w0.117: v8(110.61,36.82) 110.57,36.86 T45.1
SLP_SUS#: length 286.4
  IN1 w0.071: v3(186.4,17.36) 186.51,17.36 187.32,16.55 187.32,16 185.03,13.71 v4(185.03,13.62)
  IN2 w0.094: v9(185.92,17.36) v3(186.4,17.36)
  IN3 w0.094: v7(93.39,23.07) 94.51,21.95 94.51,18.91 102.28,11.14 107.55,11.14 127.01,11.14 127.29,11.42 132.02,11.42 132.3,11.14 139.88,11.14 140.07,10.95 153.8,10.95 158.12,15.27 158.12,17.72 158.79,18.4 v8(158.82,18.4) 158.82,19.91 159.92,21.01 166.19,21.01 168.06,19.13 171.68,19.13 173.06,17.75 173.06,16.84 175.13,14.76 181.4,14.76 182.01,15.37 182.01,15.68 182.64,16.31 183.91,16.31 184.96,17.36 v9(185.92,17.36) 193.04,17.36 194.82,19.13 194.82,21.96 195.27,22.41 196.39,22.41 v8(196.41,22.39) ; v7(66.85,34.43) 67.07,34.65 69.51,34.65 69.73,34.43 73.96,34.43 74.97,35.45 74.97,36.58 77.88,39.49 79.38,39.49 80.07,40.18 82.16,40.18 83.25,41.28 83.25,42.55 85.44,44.74 v8(85.44,44.89) ; v8(98.29,28.92) 94.08,28.92 93.92,28.77 90.48,28.77 88.71,27 79.84,27 78.98,27.85 72.47,27.85 71.91,27.29 71.22,27.29 v8(70.83,26.91) 70.63,26.91 70.28,27.26 69.1,27.26 68.39,26.55 65.14,26.55 64.85,26.25 v7(63.09,26.25) 62.32,26.25 60.62,27.95 59.81,27.95 v7(59.43,28.33)
  IN4 w0.071: v8(61.72,5.7) 58.19,2.17 57.85,2.17 52.59,2.17 50.18,4.58 v8(49.14,4.58) ; v8(99.88,26.54) 99.88,25.7 97.25,23.07 v7(93.39,23.07) ; v8(66.49,40.83) 66.49,40.01 66.74,39.77 v8(66.87,39.77) 66.87,34.45 v7(66.85,34.43) 66.59,34.18 66.59,34.01 65.96,33.38 65.96,32.73 64.86,31.63 63.74,31.63 63.24,31.13 62.21,31.13 59.43,28.35 v7(59.43,28.33) ; v8(55.2,8.15) 55.2,8.73 54.93,9 54.93,9.91 55.12,10.1 55.7,10.1 57.45,11.85 57.45,12.97 57.98,13.51 57.98,13.8 57.86,13.93 57.86,19.39 58.37,19.9 58.37,21.05 59.58,22.26 59.58,22.75 v7(63.09,26.25)
  BOTTOM w0.076: U17.N2 54.55,7.91 54.79,8.15 v8(55.2,8.15) 55.51,8.47 55.68,8.47 56.11,8.03
  BOTTOM w0.117: PR209.2 71.22,26.37 71.06,26.53 71.06,26.68 v8(70.83,26.91) ; v8(66.49,40.83) 65.98,40.83 v4(65.77,40.62) 65.58,40.62 65.22,40.98 PR142.2 ; 56.11,8.03 56.71,7.43 57.72,7.43 58.27,7.98 59.83,7.98 59.84,7.99 60.04,7.99 60.04,7.98 60.07,7.98 v4(60.89,7.16) 61.72,6.34 v8(61.72,5.7) ; R232.2 98.27,28.94 v8(98.29,28.92) 98.56,28.65 98.8,28.65 99.07,28.38 99.07,28.04 98.72,27.69 98.72,26.73 98.91,26.54 v8(99.88,26.54) ; PR238.1 v8(196.41,22.39) ; v4(185.03,13.62) 185.03,13.35 185.23,13.15 185.23,12.37 183.7,10.84 183.7,10.33 184.02,10.01 184.4,10.01 184.68,9.73 PR525.1 ; PR263.1 159.33,18.91 v8(158.82,18.4) ; v8(66.87,39.77) 66.87,39.83 67.13,40.09 PR155.1 67.3,40.28 67.68,40.65 67.68,40.86 67.66,40.88 PR146.2
SLP_SUS#_CPU: length 21.6
  TOP w0.06: v11(110.31,34.85) 110.51,34.65 U3.BN10
  IN1 w0.071: v2(105.66,33.8) 105.99,33.8 106.49,34.3 106.98,34.3 107.09,34.41 107.43,34.41 107.75,34.08 109.75,34.08 109.88,34.21 109.88,34.32 110.21,34.65 110.21,34.75 v11(110.31,34.85)
  GND1 w0.117: v9(105.3,33.49) 105.35,33.49 v2(105.66,33.8)
  IN3 w0.094: v9(105.3,33.49) 105.3,33.11 105.45,32.96 105.45,29.32 103.3,27.16 99.18,27.16 98.72,27.62 98.72,28.67 v8(98.98,28.92)
  BOTTOM w0.117: v8(98.98,28.92) 98.72,29.18 R232.1 99.1,29.96 v4(99.33,29.73)
SLP_SUS#_DS3: length 10.2
  BOTTOM w0.117: U17.M12 49.14,8.66 48.36,8.66 47.67,7.98 47.24,7.98 46.98,8.24 46.35,8.24 46.07,7.95 R10961.1 46.07,6.49 46.25,6.31 48.56,6.31 v4(49.14,5.72) R10949.1 R10948.1
SM_RCOMP_0: length 3.4
  TOP w0.305: U3.BF64 127.06,36.23 129.51,36.23 129.56,36.18 R127.2
SM_RCOMP_1: length 3.5
  TOP w0.305: R129.2 127.96,35.36 127.5,35.82 127.19,35.82 127.04,35.67 U3.BJ64
SM_RCOMP_2: length 3.5
  TOP w0.305: R122.2 130.1,37.04 127.91,37.04 127.65,36.79 127.14,36.79 U3.BC64
SM_VREF_CA: length 49.1
  GND1 w0.254: v9(124.35,38.99) 124.17,39.16 v12(124.17,39.27)
  IN3 w0.508: 156.66,27.26 156.66,27.62 156.41,27.87 156.41,40.04 155.85,40.6 153.69,40.6 150.49,43.8 142.89,43.8 138.21,39.12 137.22,39.12 136.8,38.7 124.62,38.7 124.35,38.98 v9(124.35,38.99)
  vias: v4(156,26.82) v7(156.66,26.68) v7(156.66,26.37) v8(156.66,26.68) v8(156.66,26.37) v10(156.66,26.68) v10(156.66,26.37)
SM_VREF_DQ0: length 12.2
  GND1 w0.254: v2(124.17,39.96) 124.17,39.87 v9(124.4,39.64)
  IN3 w0.508: v9(124.4,39.64) 124.51,39.75 129.5,39.75 129.99,40.24 135.95,40.24
  vias: v4(136.72,39.63) v7(136.62,40.11) v7(136.95,40.11) v8(136.62,40.11) v8(136.95,40.11) v10(136.62,40.11) v10(136.95,40.11)
SM_VREF_DQ1: length 11.2
  GND1 w0.254: v9(124.33,37.78) 124.3,37.78 124.28,37.8 124.23,37.8 v12(124.04,38)
  IN3 w0.508: 124.86,27.19 124.33,27.72 v9(124.33,37.78)
  vias: v4(125.95,26.7) v7(124.63,26.19) v7(125.04,26.19) v8(124.63,26.19) v8(125.04,26.19) v10(124.63,26.19) v10(125.04,26.19)
SMC: length 8.1
  IN4 w0.071: v8(73.6,12.07) 73.7,11.97 75.74,11.97 76.17,11.54 78.02,11.54 78.32,11.24 v8(78.32,11.01)
  BOTTOM w0.117: PR309.1 71.81,13.25 72.02,13.25 v4(72.28,12.99) 72.33,12.94 72.33,12.78 73.04,12.07 v8(73.6,12.07)
SMCLK0: length 13
  BOTTOM w0.117: Q33.4 145.67,5.41 146.12,5.85 R455.1 146.12,6.23 145.95,6.4 145.9,6.4 145.67,6.63 R456.1 145.67,7.15 145.89,7.37 146.56,7.37 146.88,7.69 147.5,7.69 148.51,6.69 148.51,4.76 v4(148.58,4.68) 148.51,4.6 148.51,3.95 149.15,3.31 150.29,3.31 150.59,3.61 150.59,3.98 150.65,4.04 150.67,4.04 150.81,4.19 150.81,4.49 151.06,4.74 U20.G2
SMCLK4_ACC1: length 273
  TOP w0.117: v1(88.26,31.36) 88.51,31.61 v4(88.51,31.81) 88.51,32.96 86.61,34.86 86.61,34.98 86.3,35.29 U5.4
  IN1 w0.071: v4(167.76,15.55) 169.39,13.93 170.35,13.93 171.43,12.84 182.97,12.84 183.23,12.59 184.89,12.59 185.9,13.6 185.9,13.87 187.82,15.79 187.82,17.2 187.62,17.4 187.62,21.91 186.51,23.02 186.51,27.56 187.6,28.65 187.6,33.31 189.76,35.47 189.76,36.43 192.68,39.35 192.68,48.59 192.58,48.68 192.44,48.68 192.35,48.59 192.35,47.18 192.25,47.08 192.09,47.08 191.99,47.18 191.99,48.58 191.89,48.68 191.74,48.68 191.64,48.58 191.64,47.36 191.54,47.26 191.4,47.26 191.31,47.36 191.31,47.92 191.21,48.02 191.07,48.02 190.98,47.92 190.98,47.03 191.4,46.61 v4(191.78,46.61) ; v4(166.39,7.35) 164.08,7.35 163.19,6.46 160.83,6.46 159.41,5.04 153.57,5.04 153.23,4.71 151.02,4.71 150.68,5.04 133.73,5.04 132.76,4.07 131.69,4.07 130.68,5.09 105.73,5.09 104.72,4.07 92.68,4.07 89.38,7.37 89.38,12.63 87.82,14.19 87.35,14.19 86.83,14.7 86.83,20.79 85.31,22.31 85.31,28.02 88.26,30.97 v1(88.26,31.36) 88.02,31.36 83.68,27.02 72.76,27.02 71.45,25.7 65.72,25.7 65.01,24.99 60.41,24.99 59.42,24 58.12,24 57.45,24.67 51.33,24.67 50.34,23.68 47.11,23.68 40.18,16.75 40.18,16.29 38.99,15.11 29.44,15.11 28.62,14.28 25.35,14.28 v4(24.93,14.71)
  IN3 w0.094: v4(166.39,7.35) 166.39,7.36 167.96,8.94 167.96,14.1 168.17,14.31 168.17,14.94 167.76,15.35 v4(167.76,15.55)
  BOTTOM w0.117: R169.1 192.42,50.56 192.3,50.43 192.3,48.48 192.17,48.35 R179.1 191.86,48.35 191.21,48.35 191.02,48.16 Q10.4 191.02,46.8 191.21,46.61 v4(191.78,46.61) ; v4(167.76,15.55) 167.76,16.19 167.48,16.47 166.06,16.47 165.68,16.85 R382.1 165.48,16.65 165.35,16.52 164.38,16.52 164.23,16.67 R404.1 ; CN9.19 25.05,14.58 v4(24.93,14.71)
SMCLK4_HUB: length 22.8
  IN3 w0.094: v8(162.55,16.8) 161.28,16.8 161.14,16.65 161.14,16.35 161.25,16.24 161.75,16.24 161.81,16.18 161.81,16.02 161.66,15.87 161.25,15.87 161.14,15.76 161.14,15.01 156.23,10.1 v8(156.23,9.61)
  BOTTOM w0.117: R382.2 164.84,16.85 164.51,17.18 163.95,17.18 163.78,17.01 R404.2 163.62,16.85 163.29,17.18 162.68,17.18 162.59,17.09 R411.2 ; U20.F9 151.56,9.29 151.89,9.61 152.51,9.61 152.65,9.75 152.65,10.48 152.78,10.62 152.98,10.62 153.11,10.48 153.11,9.75 153.25,9.61 153.57,9.61 153.81,9.85 154.04,9.85 154.27,9.61 154.5,9.61 154.74,9.85 154.97,9.85 155.21,9.61 v8(156.23,9.61)
SMD: length 8.6
  IN4 w0.071: v8(72.51,12.05) 71.72,12.05 71.65,11.97 71.65,11.82 71.72,11.74 75.64,11.74 75.99,11.39 76.69,11.39 v8(77.07,11.01)
  BOTTOM w0.117: v8(72.51,12.05) 72.23,11.77 v4(71.85,11.77) 71.48,12.14 PR314.1
SMDAT0: length 13.6
  BOTTOM w0.117: U20.G1 151.06,4.1 151.02,4.05 151.02,3.59 150.42,2.99 149.94,2.99 v4(149.73,2.78) 149.51,2.99 149.01,2.99 148.19,3.82 148.19,6.55 147.37,7.37 147.01,7.37 146.88,7.25 146.88,7.14 147.11,6.92 R488.1 R489.1 147.11,5.78 147.24,5.64 147.24,3.75 146.97,3.48 Q33.1
SMDAT4_ACC1: length 270.9
  TOP w0.117: v1(88.83,31.28) 89.25,31.7 v4(89.25,32.87) 89.05,32.87 87,34.92 87,35.1 86.63,35.47 86.63,36.06 85.67,37.02 85.03,37.02 84.9,36.89 U5.6
  IN1 w0.071: v4(167,7.35) 166.64,7.7 164.05,7.7 163.11,6.76 160.74,6.76 159.3,5.32 153.44,5.32 153.11,4.99 151.15,4.99 150.82,5.32 133.61,5.32 132.64,4.35 131.81,4.35 130.79,5.36 105.62,5.36 104.6,4.35 92.79,4.35 89.65,7.49 89.65,12.74 87.94,14.46 87.46,14.46 87.11,14.82 87.11,21.89 85.59,23.41 85.59,27.91 88.83,31.16 v1(88.83,31.28) 88.64,31.48 88.51,31.48 88.36,31.63 87.91,31.63 83.57,27.29 72.65,27.29 71.33,25.98 65.44,25.98 64.72,25.26 60.22,25.26 59.25,24.29 58.41,24.29 57.76,24.94 51.22,24.94 50.23,23.95 47,23.95 39.9,16.86 39.9,16.4 38.88,15.38 25.68,15.38 v4(25.39,15.09) ; v4(168.35,15.55) 168.37,15.55 169.64,14.28 170.5,14.28 171.67,13.12 183.08,13.12 183.34,12.86 184.77,12.86 185.58,13.66 185.58,13.94 187.54,15.9 187.54,17.09 187.35,17.28 187.35,21.75 186.23,22.87 186.23,27.67 187.22,28.66 187.22,33.48 189.48,35.75 189.48,36.66 192.4,39.58 192.4,45.07 188.1,49.37 v4(188.1,50.49)
  IN3 w0.094: v4(168.35,15.55) 168.46,15.43 168.46,14.12 168.27,13.93 168.27,8.82 167,7.55 v4(167,7.35)
  BOTTOM w0.117: Q10.1 189.72,48.84 189.56,48.69 R177.1 R184.1 188.31,48.07 188.1,48.28 v4(188.1,50.49) ; v4(25.39,15.09) 25.39,14.71 25.55,14.56 CN9.20 ; R405.1 164.23,16.01 164.41,16.19 165.37,16.19 165.48,16.08 R383.1 165.68,15.83 166,16.15 167.11,16.15 167.37,15.89 167.37,15.35 167.55,15.17 167.96,15.17 v4(168.35,15.55)
SMDAT4_HUB: length 17.8
  IN3 w0.094: v8(162.55,15.86) 162.07,15.86 161.43,15.22 161.43,14.89 156.53,9.98 156.53,9.55 v8(156.23,9.25)
  BOTTOM w0.117: v8(156.23,9.25) 152.29,9.25 152.01,8.98 152.01,8.34 U20.E9 ; R383.2 164.86,15.83 164.54,15.5 163.9,15.5 163.78,15.62 R405.2 163.65,15.83 163.32,15.5 162.68,15.5 162.59,15.59 R412.2
SML0_CLK: length 2.2
  GND1 w0.127: v9(109.44,44.64) 109.32,44.51 v2(109.09,44.51)
  GND2 w0.127: v8(109.14,44.28) 109.44,44.58 v9(109.44,44.64)
  BOTTOM w0.117: v8(109.14,44.28) 108.91,44.51 v4(108.66,44.51) 108.5,44.35 R188.1
SML0_DATA: length 1.3
  GND1 w0.127: v2(110.46,43.11) 110.46,43.32 110.21,43.56 v9(110.21,43.7)
  GND2 w0.127: v8(109.79,43.23) 109.83,43.23 110.21,43.62 v9(110.21,43.7)
SML0ALERT#: length 4.9
  TOP w0.117: v1(107.84,44.61) 107.31,44.61 107.13,44.43 106.09,44.43 105.9,44.62 R55.2
  IN1 w0.06: v1(107.84,44.61) 107.94,44.51 108.76,44.51 108.99,44.28 109.19,44.28 109.54,43.92 109.54,43.86 v1(109.62,43.78)
SML1_CLK: length 64.9
  IN1 w0.06: 106.22,44.14 107.95,44.14 108.17,43.92 108.53,43.92 108.63,43.82 108.83,43.82 108.91,43.9 109.06,43.9 v2(109.14,43.82)
  IN1 w0.071: 106.22,44.14 100.47,44.14 100.27,43.95 99.49,43.95 99.21,44.23 v3(98.8,44.23)
  GND1 w0.127: v2(109.14,43.82) 108.93,43.62 108.71,43.62 108.48,43.39 v9(108.4,43.39)
  IN2 w0.094: v4(62.88,32.06) 63.47,32.65 64.33,32.65 66.78,35.09 71.74,35.09 73.16,33.67 74.81,33.67 75.46,34.32 76.24,34.32 76.56,34.64 79.99,34.64 80.45,35.09 81.13,35.09 81.73,35.69 83.63,35.69 83.93,35.99 83.93,36.85 84.72,37.64 84.72,39.57 88.57,43.42 90.45,43.42 93.16,46.13 96.21,46.13 97.94,44.41 98.62,44.41 v3(98.8,44.23)
  GND2 w0.127: v8(108.53,43.09) 108.4,43.21 v9(108.4,43.39)
  BOTTOM w0.117: v4(62.88,32.06) 63.54,32.06 v4(63.89,31.72) 64.26,31.35 64.26,29.75 63.44,28.94 61.72,28.94 61.22,29.43 Q6064.4
SML1_DATA: length 63.6
  IN1 w0.06: 103.63,45.76 104.52,45.76 104.62,45.66 104.92,45.66 105.34,45.24 106.95,45.24 107.39,45.68 108.38,45.68 108.77,45.28 109.42,45.28 109.73,44.97 110.08,44.97 110.51,44.54 v2(110.51,44.45)
  IN1 w0.071: v3(98.11,44.71) 98.44,45.04 100.56,45.04 100.76,45.24 101.7,45.24 101.95,45.5 103.32,45.5 103.58,45.76 103.63,45.76
  GND1 w0.127: v9(110.33,44.74) 110.51,44.56 v2(110.51,44.45)
  IN2 w0.094: v4(61.89,32.06) 62.76,32.93 64.36,32.93 66.71,35.27 71.87,35.27 73.29,33.85 74.73,33.85 75.37,34.48 76.18,34.48 76.51,34.81 79.91,34.81 80.37,35.27 80.95,35.27 81.6,35.92 83.64,35.92 83.76,36.04 83.76,36.93 84.54,37.71 84.54,39.64 88.5,43.6 90.37,43.6 93.11,46.34 96.49,46.34 v3(98.11,44.71)
  GND2 w0.127: v9(110.33,44.74) 110.33,44.33 110.06,44.06 109.65,44.06 v8(109.11,43.53)
  BOTTOM w0.117: v4(61.89,32.06) 61.89,30.91 62.07,30.73 Q6064.1
SML1ALERT#: length 9.8
  TOP w0.117: R103.2 101.67,37.68 101.37,37.38 v1(101.37,37.1)
  IN1 w0.06: 109.46,37.29 109.04,36.87 108.97,36.87 108.9,36.8 108.63,36.8 108.6,36.77 108.48,36.77
  IN1 w0.071: v1(101.37,37.1) 101.47,37 103.36,37 103.55,37.19 104.04,37.19 104.16,37.08 105.35,37.08 105.65,36.77 106.19,36.77 106.52,37.1 107.54,37.1 107.87,36.77 108.48,36.77 ; v1(109.47,37.29) 109.46,37.29
SMLALERT#: length 1.5
  GND1 w0.127: v2(110.04,44.43) 110.29,44.18 110.89,44.18 v9(110.97,44.25)
  GND2 w0.127: v9(110.97,44.25) 110.97,44.11 110.82,43.97 v8(110.77,43.97)
SOC_DPST_PWM: length 121.8
  IN1 w0.071: v4(16.22,12.21) 20.05,16.05 35.94,16.05 37.12,17.24 38.76,17.24 42.08,20.56 42.97,20.56 45.77,23.36 45.77,25.44 47.03,26.7 58.16,26.7 59.04,27.58 63.52,27.58 63.97,28.02 67.3,28.02 68.02,28.73 72.23,28.73 73.1,29.6 80.76,29.6 85.56,34.4 88.59,34.4 88.77,34.22 89.05,34.22 89.22,34.04 91.5,34.04 93.16,35.7 93.16,36.1 93.4,36.34 93.4,41.01 94.89,42.5 v2(94.89,42.56)
  GND1 w0.117: v2(94.89,42.56) 95.12,42.79 v9(95.12,42.87) ; v2(109.51,49.01) 109.51,49.05 v9(109.88,49.42)
  IN3 w0.094: v9(109.88,49.42) 109.84,49.38 109,49.38 108.14,50.24 108.14,52.06 107.44,52.76 105.18,52.76 102.69,50.27 97.18,50.27 96.41,49.51 96.41,44.16 v9(95.12,42.87)
  BOTTOM w0.117: v4(16.22,12.21) R408.1
SOC_EDP_BLON: length 99.8
  IN1 w0.071: v2(95.5,42.26) 95.16,41.92 94.94,41.92 93.85,40.83 93.85,36.15 93.61,35.92 93.61,35.52 91.69,33.6 91.39,33.6 90.09,32.29 88.88,32.29 88.42,32.75 87.83,32.75 84.01,28.94 73.27,28.94 72.59,28.25 68.16,28.25 67.49,27.58 64.15,27.58 63.62,27.04 59.14,27.04 58.34,26.25 57.97,26.25 47.8,26.25 v4(47.09,25.53)
  GND1 w0.117: v9(95.5,42.59) v2(95.5,42.26) ; v2(109.12,48.53) 109.15,48.51 v9(109.15,48.07)
  IN3 w0.094: v9(109.15,48.07) 109.15,48.82 107.84,50.12 107.84,51.93 107.31,52.46 105.3,52.46 102.81,49.98 97.3,49.98 96.72,49.39 96.72,43.8 v9(95.5,42.59)
  BOTTOM w0.076: U17.B10 50.13,13.67 50.13,14.15 49.72,14.57 49.72,14.59 49.71,14.6
  BOTTOM w0.117: R281.2 R282.2 46.59,25.04 v4(47.09,25.53) v4(47.75,25.53) 47.92,25.53 48.64,24.82 48.64,22.56 48.81,22.38 48.81,20.33 48.64,20.15 48.64,15.67 49.71,14.6
SOC_EDP_ENVDD: length 48.6
  GND1 w0.117: v3(109.09,48.96) 108.68,48.55 v2(108.68,48.53)
  IN2 w0.094: v9(108.43,53.61) 108.25,53.43 108.25,50.99 108.74,50.5 108.74,49.58 109.09,49.24 v3(109.09,48.96)
  IN3 w0.094: v8(96.31,51.77) 97.83,53.29 106.72,53.29 107.28,53.86 108.18,53.86 v9(108.43,53.61)
  BOTTOM w0.117: PR170.2 80.61,35.52 80.97,35.87 80.97,36.53 80.61,36.89 80.31,36.89 79.88,37.32 79.88,38.51 80.59,39.22 84.23,39.22 86.39,41.38 v4(86.39,43.45) 87.24,44.3 91.23,44.3 92.68,45.75 92.68,50.1 94.35,51.77 v8(96.31,51.77)
SPI_CLK: length 7.6
  TOP w0.109: C3.1 45.97,49.13 44.39,47.56 43.43,47.56 42.79,46.92 U1.6 ; C3.1 R14.1 R16.2 ; C3.1 46.62,49.41 v4(46.65,49.38)
SPI_CS#: length 3.5
  TOP w0.109: U1.1 48.23,44.38 47.54,43.7 R5.2 R1.2
SPI_IO2: length 9.5
  TOP w0.102: 45.47,43.14 R13.2
  TOP w0.109: R13.2 R15.1 ; 45.47,43.14 45.76,43.44 45.76,44.3 48.38,46.92 U1.3 51.12,46.92 v4(51.61,47.4)
SPI_IO3: length 5.9
  TOP w0.102: 42.66,43.13 R6.1
  TOP w0.109: R11.2 R9.2 R6.1 ; 42.66,43.13 43.43,43.9 43.43,44.94 42.72,45.65 U1.7
SPI_SI: length 5.2
  TOP w0.109: v4(43.68,50.91) 43.68,50.27 43.55,50.15 43.38,50.15 43.25,50.02 43.25,49.64 43.12,49.51 42.96,49.51 R17.2 ; R18.1 43.4,49.21 43.12,49.21 R17.2 ; R17.2 42.77,49.32 42.77,48.87 42.89,48.75 42.89,48.44 42.64,48.19 U1.5
SPI_SO: length 5.6
  TOP w0.109: U1.2 50.39,45.65 50.62,45.42 50.62,43.97 v4(50.18,43.54) 49.27,43.54 49.04,43.31 R8.1 R10.2
