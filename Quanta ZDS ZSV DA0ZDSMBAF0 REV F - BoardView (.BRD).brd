# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN4 (solid shape): 177.89,58.49 183.91,58.49 183.91,61.49 190.64,61.49 190.64,58.49 197.16,58.49 197.16,61.49 208.5,61.49 208.85,61.35 208.99,61 208.99,58.51 202.99,58.51 202.99,55.69 208.99,55.69 208.99,54.76 208.9,54.68 201.98,54.68 201.98,60.48 198.17,60.48 198.17,57.48 189.63,57.48 189.63,60.48 184.92,60.48 184.92,57.48 176.88,57.48 176.88,60.48 173.8,60.48 172.19,58.88 172.19,55.51 170.4,53.71 167.67,53.71 165.68,55.7 165.68,58.56 163.77,60.48 67.29,60.48 65.86,59.05 65.86,55.53 64.06,53.73 61.54,53.73 59.71,55.56 59.71,58.91 58.14,60.48 23.12,60.48 23.12,55.22 32.32,55.22 32.32,54.34 34.79,54.34 34.89,54.39 35.18,54.5 35.48,54.56 36.3,54.47 37.01,54.05 37.04,53.97 37,53.89 36.96,53.87 36.92,53.83 36.71,53.56 36.62,53.23 36.54,53.14 36.43,53.18 35.8,53.55 35.1,53.33 31.87,53.33 31.87,53.33 31.31,53.33 31.31,54.06 22.6,54.06 22.25,54.2 22.11,54.55 22.11,54.8 22.11,54.8 22.11,61 22.25,61.35 22.6,61.49 177.89,61.49
GND on IN4 (solid shape): 232.27,9.39 232.21,9.2 232.27,9.01 232.27,8.73 232.21,8.54 232.27,8.35 232.27,1.52 261.93,1.52 261.93,1.58 266.32,1.58 267.01,2.27 268.57,2.27 269.24,1.59 270.27,1.59 270.49,1.37 270.49,0.51 269.28,0.51 267.6,1.76 265.91,0.51 231.26,0.51 231.26,9.02 223.04,9.02 223.04,7.76 217.29,7.76 217.29,4.55 217.25,4.47 217.15,4.46 217.06,4.47 216.98,4.43 216.95,4.42 216.81,4.47 216.69,4.43 216.66,4.42 216.62,4.43 216.52,4.47 216.42,4.45 216.33,4.46 216.28,4.54 216.28,4.79 216.32,4.79 216.48,4.91 216.46,5.1 216.45,5.13 216.49,5.27 216.45,5.4 216.46,5.43 216.48,5.62 216.32,5.74 216.28,5.74 216.28,8.77 222.03,8.77 222.03,10.03 232.27,10.03
GND on IN4 (solid shape): outline of 168 points within 114.95,38.56 125.11,46.47
GND on IN4 (solid shape): outline of 102 points within 0.51,0.51 223.04,30.96
GND on IN4 (solid shape): 271.4,45.99 271.75,45.85 271.89,45.5 271.89,45.23 271.7,45.04 271.22,45.04 269.22,43.64 271.48,42.73 271.79,42.73 271.89,42.63 271.89,39.99 274.79,39.99 274.79,38.49 271.92,38.49 270.79,38.95 270.04,37.98 270.04,36.72 269.37,36.05 268.85,36.05 268.74,36.15 268.74,36.28 269.16,36.55 269.32,37.02 269.32,37.18 268.88,37.87 268.07,37.78 267.5,37.78 264.8,40.48 257.42,40.48 257.42,36.48 248.42,36.48 248.42,29.28 205.09,29.28 204.12,30.26 204,30.37 203.9,30.49 204.3,30.79 204.49,31.25 204.61,31.25 205.36,30.77 206.16,31.16 208.99,31.16 208.99,30.29 247.41,30.29 247.41,35.74 247.41,35.74 247.41,36 247.57,36.68 248.03,37.21 248.44,37.42 248.9,37.49 249.41,37.49 249.41,37.49 256.41,37.49 256.41,41 256.55,41.35 256.9,41.49 264.91,41.49 264.91,45.5 265.05,45.85 265.4,45.99
GND on IN4 (solid shape): outline of 284 points within 69.92,51.33 84.04,59.35
GND on IN4 (solid shape): outline of 2915 points within 2.2,9.87 49.5,59.93
GND on IN4 (solid shape): outline of 3630 points within 191.69,16.44 225.85,55.25
GND on IN4 (solid shape): outline of 3785 points within 113.38,30.61 155.65,42.7
GND on IN4 (solid shape): outline of 6303 points within 229.86,2.73 274.79,36.94
GND on IN4 (solid shape): outline of 10494 points within 99.79,12.22 153.31,25.31
PVDD on TOP (solid shape): outline of 523 points within 224.38,5.01 235.72,13.48
PVDD on BOTTOM (solid shape): 234.11,6.29 234.11,5.5 233.88,5.27 232.82,5.27 232.68,5.41 232.68,6.31 232.72,6.34 234.06,6.34
PVDD on BOTTOM (solid shape): 226.69,11.92 226.69,10.65 226.58,10.54 223.49,10.54 223.39,10.65 223.39,11.54 223.51,11.67 224.53,11.67 224.91,12.05 226.56,12.05
V1.00A_SRC on TOP (solid shape): 60.29,37.47 60.29,35.85 59.43,34.98 59.43,34.04 59.05,33.66 55.01,33.66 54.81,33.87 54.81,35.67 54.93,35.74 55.01,35.87 55.8,36.66 55.8,37.22 56.48,37.9 59.86,37.9
V1.00A_SRC on BOTTOM (solid shape): 59.4,35.31 59.4,33.34 59.23,33.34 59.23,31.71 59.02,31.5 58.16,31.5 57.83,31.83 57.83,33.26 57.5,33.59 54.48,33.59 54.35,33.71 54.35,34.22 55.84,35.71 59.01,35.71
V1.00A_SRC on IN1 (solid shape): 59.23,36.67 59.23,33.92 58.97,33.66 57.92,33.66 56.05,35.52 56.05,36.75 56.38,37.07 58.84,37.07
V1.00A_SRC on IN2 (solid shape): 59.23,35.71 59.23,33.76 58.87,33.4 56.33,33.4 56.05,33.67 56.05,36.75 56.38,37.07 57.87,37.07
V1.00A_VIN on TOP (solid shape): 64.87,38.23 64.87,37.75 64.72,37.61 64.3,37.61 63.72,37.03 63.72,36.33 63.9,36.15 63.9,35.85 63.75,35.7 61.92,35.7 61.84,35.78 61.84,36.99 61.68,37.15 60.95,37.15 60.85,37.25 60.85,37.68 60.93,37.76 63.73,37.76 64.3,38.33 64.76,38.33
V1.00A_VIN on BOTTOM (solid shape): 63.6,37.79 63.6,36.51 63.82,36.28 63.82,34.78 63.59,34.55 61.63,34.55 61.01,35.18 61.01,36.55 60.17,37.4 60.17,37.86 60.24,37.94 63.44,37.94
V1.8A_SRC on TOP (solid shape): 70.66,36.36 70.66,35.32 70.86,35.12 71.65,35.12 71.8,34.97 71.8,34.1 71.62,33.92 68.22,33.92 67.58,34.56 67.58,36.46 67.84,36.72 70.3,36.72
V3.3A_DSW_VIN on TOP (solid shape): 79.9,40.76 79.9,37.89 79.73,37.71 75.82,37.71 75.82,37.81 74.89,37.81 74.89,37.8 74.67,38.01 74.67,39.31 74.92,39.56 76.4,39.56 76.68,39.84 76.68,40.35 76.5,40.53 76.04,40.53 75.92,40.66 75.92,41.01 76.02,41.11 79.55,41.11
V3.3A_PCH_S2 on TOP (solid shape): 86.85,44.01 87.72,44.01 87.72,43.19 87.92,43.19 87.92,44.01 88.06,44.01 88.11,43.96 88.11,42.81 87.62,42.33 86.82,42.33 86.82,42.38 86.05,42.38 85.9,42.53 85.9,43.88 86.13,44.11 86.75,44.11
V4_VCCIO on TOP (solid shape): 51.68,35.68 51.68,35.1 52.77,34 52.77,32.67 52.5,32.39 51.3,32.39 51.25,32.34 49.83,32.34 49.52,32.65 49.52,35.01 50.35,35.84 51.52,35.84
V4_VCCIO on TOP (solid shape): 114.84,43.27 114.84,43 115.06,42.78 115.31,42.78 115.33,42.75 115.33,41.87 115.42,41.78 115.42,38.59 115.38,38.55 115.05,38.55 115.03,38.57 115.03,41.81 114.96,41.89 114.6,41.89 114.49,42 114.49,42.33 114.42,42.4 114.07,42.4 114.02,42.45 114.02,43.28 114.07,43.34 114.77,43.34
V4_VCCIO on TOP (solid shape): outline of 122 points within 115.21,37.9 123.52,38.4
V4_VCCIO on BOTTOM (solid shape): 115.21,42.53 115.21,39.17 115.05,39.01 114.79,39.01 114.67,39.13 114.67,42.55 114.73,42.6 115.13,42.6
V4_VCCIO on BOTTOM (solid shape): 51.05,36.41 51.05,35.85 52.07,34.82 52.07,33.97 51.81,33.7 51.81,31.68 51.25,31.12 49.83,31.12 49.73,31.22 49.73,35.19 49.63,35.29 49.63,36.41 49.73,36.51 50.95,36.51
V4_VCCIO on BOTTOM (solid shape): 116.12,38.41 119.73,38.41 119.8,38.49 120.54,38.49 120.75,38.28 124.18,38.28 124.53,37.93 125.11,37.93 125.19,37.85 125.19,37.45 125.13,37.39 123.37,37.39 122.9,37.85 122.85,37.9 118.59,37.9 118.57,37.92 117.91,37.92 117.85,37.98 115,37.98 114.88,38.1 114.88,38.29 115,38.41 115.22,38.41 115.23,38.42 115.44,38.42 115.67,38.64 115.89,38.64
V4_VCCIO on IN1 (solid shape): 115.34,42.82 115.34,42.29 115.38,42.25 115.38,38.58 115.36,38.56 115.01,38.56 114.98,38.59 114.98,41.76 114.81,41.92 114.66,41.92 114.01,42.57 114.01,43.17 114.02,43.19 114.03,43.21 114.11,43.29 114.87,43.29
V4_VCCIO on IN1 (solid shape): 118.2,38.45 118.26,38.45 123.14,38.45 123.2,38.4 123.2,38.25 123.13,38.17 115.9,38.17 115.75,38.02 115.75,37.97 115.69,37.91 115.47,37.91 115.21,38.17 115.21,38.36 115.26,38.41 115.51,38.41 115.55,38.45 118.15,38.45
V4_VCCIO on GND1 (solid shape): 115.07,43.05 115.07,42.88 115.23,42.72 115.32,42.72 115.35,42.7 115.36,42.67 115.36,42.01 115.28,41.82 115.36,41.62 115.36,41.39 115.29,41.2 115.36,41.02 115.36,40.82 115.29,40.64 115.36,40.47 115.36,40.32 115.36,40.3 115.35,40.28 115.27,40.09 115.35,39.91 115.36,39.89 115.36,39.87 115.36,39.68 115.35,39.67 115.32,39.54 115.35,39.4 115.36,39.39 115.36,38.62 115.29,38.54 115.14,38.54 115.1,38.56 115.04,38.59 114.97,38.59 114.95,38.6 114.92,38.63 114.91,38.73 114.89,38.8 114.88,38.81 114.88,39.13 114.89,39.14 114.92,39.25 114.89,39.36 114.88,39.37 114.88,39.73 114.88,39.74 114.89,39.81 114.88,39.88 114.88,39.88 114.88,40.85 114.88,40.86 114.89,40.93 114.88,40.99 114.88,41 114.88,41.38 114.88,41.39 114.89,41.46 114.88,41.53 114.88,41.54 114.88,41.69 114.85,41.69 114.04,42.5 114.04,43.19 114.14,43.29 114.83,43.29
V4_VCCIO on GND1 (solid shape): outline of 88 points within 115.26,37.9 123.29,38.46
V4_VCCIO on IN2 (solid shape): 118.2,38.45 118.28,38.46 123.14,38.46 123.23,38.38 123.23,38.02 123.11,37.9 115.42,37.9 115.24,38.08 115.24,38.22 115.25,38.31 115.25,38.39 115.26,38.4 116.05,38.4 116.11,38.46 118.13,38.46
V4_VCCIO on IN2 (solid shape): 115.03,43.01 115.03,42.88 115.66,42.25 115.68,42.16 115.62,42.08 115.58,42.08 115.3,41.88 115.45,41.57 115.48,41.54 115.48,41.51 115.47,41.48 115.45,41.45 115.31,41.3 115.32,41.09 115.35,41.03 115.41,40.98 115.43,40.92 115.41,40.86 115.37,40.83 115.29,40.63 115.4,40.43 115.41,40.38 115.39,40.32 115.3,40.22 115.27,40.09 115.31,39.96 115.4,39.86 115.43,39.8 115.41,39.74 115.38,39.37 115.76,39.33 115.85,39.31 115.89,39.23 115.89,39.1 115.88,39.02 115.89,38.94 115.89,38.61 115.83,38.56 115.12,38.56 115.08,38.57 115.04,38.59 114.54,39.08 114.54,41.38 114.11,41.81 114.11,43.18 114.18,43.25 114.78,43.25
V4_VCCIO on SVCC (solid shape): outline of 177 points within 48.63,24.55 122.91,43.47
V4_VCCIO on IN3 (solid shape): 120.85,38.36 120.85,38.06 120.69,37.9 115.59,37.9 115.56,37.93 115.56,38.19 115.86,38.49 120.72,38.49
V4_VCCIO on IN3 (solid shape): 115.24,41.98 115.24,41.2 115.25,41.19 115.26,41.12 115.29,41.05 115.29,40.8 115.26,40.64 115.29,40.51 115.29,40.5 115.29,40.27 115.23,40.09 115.29,39.91 115.29,39.63 115.29,39.61 115.31,39.4 115.47,39.25 115.47,38.81 115.28,38.61 114.83,38.61 114.79,38.64 114.78,38.69 114.78,41.91 114.93,42.06 115.16,42.06
V4_VCCIO on GND2 (solid shape): 120.78,38.46 121.01,38.46 121.16,38.41 121.3,38.46 121.52,38.46 121.66,38.41 121.81,38.46 122.03,38.46 122.15,38.43 122.27,38.46 122.86,38.46 123.01,38.31 123.01,38.01 122.9,37.9 119.2,37.9 119.2,37.9 118.31,37.9 118.2,37.92 118.12,37.9 118.11,37.9 117.57,37.9 117.4,37.97 117.22,37.91 117.21,37.9 117.14,37.9 117.13,37.91 116.95,37.97 116.78,37.9 116.1,37.9 115.87,38.13 115.87,38.28 116.05,38.46 120.04,38.46 120.12,38.53 120.7,38.53
V4_VCCIO on GND2 (solid shape): 115.24,42.17 115.24,41.92 115.26,41.83 115.26,41.66 115.25,41.61 115.24,41.53 115.25,41.45 115.26,41.42 115.26,41.34 115.26,41.33 115.23,41.2 115.26,41.07 115.26,41.06 115.26,40.98 115.24,40.87 115.24,40.82 115.25,40.77 115.23,40.65 115.25,40.53 115.26,40.51 115.26,40.23 115.26,40.22 115.23,40.1 115.26,39.97 115.26,39.96 115.26,39.79 115.24,39.73 115.24,39.68 115.24,39.65 115.25,39.62 115.23,39.57 115.23,39.49 115.11,39.36 114.75,39.36 114.68,39.43 114.68,41.58 114.68,41.6 114.69,41.62 114.76,41.78 114.7,41.95 114.69,41.95 114.68,41.99 114.68,42.17 114.91,42.39 115.01,42.39
V4_VCCIO on IN4 (solid shape): outline of 203 points within 113.35,38.26 115.23,42.55
V4_VCCIO on IN4 (solid shape): outline of 538 points within 113.35,35.24 124.78,38.39
V5_V5A_DS3 on TOP (solid shape): 156.15,55.84 156.15,55.67 156.43,55.39 156.43,55.06 156.2,54.83 155.04,54.83 154.96,54.9 154.96,55.64 155.25,55.93 156.06,55.93
V5_V5A_DS3 on TOP (solid shape): outline of 1100 points within 187.06,2.56 200.91,19.45
V5_V5A_DS3 on BOTTOM (solid shape): 172.92,31.92 172.92,30.5 172.79,30.37 171.9,30.37 171.75,30.52 171.75,31.92 171.88,32.04 172.79,32.04
V5_V5A_DS3 on BOTTOM (solid shape): 178.35,29.75 178.35,29 177.54,28.18 177.41,28.18 177.34,28.26 177.34,28.44 177.64,28.74 177.64,29.76 177.78,29.91 178.19,29.91
V5_V5A_DS3 on BOTTOM (solid shape): 192.86,8.72 192.9,8.7 192.91,8.67 192.91,6.43 192.9,6.4 192.86,6.38 191.46,6.38 191.18,6.11 189.88,6.11 189.72,5.95 188.97,5.95 188.84,6.08 188.84,8.11 188.97,8.24 189.59,8.24 189.62,8.23 189.63,8.22 189.88,8.1 190.13,8.22 190.15,8.23 190.17,8.24 191.03,8.24 191.51,8.72
V5_V5A_DS3_R on BOTTOM (solid shape): 189.34,9.25 189.34,8.73 189.13,8.52 188.93,8.52 188.58,8.17 188.58,7.39 188.59,7.39 188.59,7.34 188.54,7.3 187.49,7.3 186.81,7.97 186.81,8.26 187.26,8.71 187.58,8.71 187.63,8.76 187.63,9.04 188.41,9.04 188.41,9.24 187.63,9.24 187.63,9.34 187.74,9.44 188.41,9.44 188.41,9.45 189.14,9.45
V5_V5A_DSW on TOP (solid shape): 58.36,59.24 58.36,57.67 58.32,57.38 58.29,57.08 57.91,56.7 55.24,56.7 54.83,57.11 54.83,59.44 55.04,59.65 57.96,59.65
V5_V5A_DSW on TOP (solid shape): 195.54,21.01 195.56,20.91 195.49,20.84 195.35,20.31 195.88,20.45 195.95,20.52 196.05,20.49 196.8,19.75 198.67,19.75 198.93,19.49 198.93,17.12 198.7,16.89 196.04,16.89 192.96,19.97 192.96,20.41 193.7,21.15 195.4,21.15
V5_V5A_DSW on TOP (solid shape): outline of 4168 points within 50.83,2.5 186.56,31.54
V5_V5A_DSW on BOTTOM (solid shape): 186.25,9.38 186.25,9.24 185.46,9.24 185.46,9.04 186.25,9.04 186.25,8.9 186.49,8.66 186.49,7.34 186.27,7.12 184.42,7.12 184.14,7.4 184.14,8.82 184.7,8.82 185.26,9.38 185.26,9.38 185.32,9.44 186.19,9.44
V5_V5A_DSW on BOTTOM (solid shape): 194.15,21.71 194.15,21.2 194.56,20.79 194.56,20.05 194.3,19.79 193.03,19.79 192.63,20.2 192.63,21.39 192.64,21.43 192.68,21.44 193.47,21.44 193.47,21.65 192.68,21.65 192.64,21.66 192.63,21.7 192.63,21.76 192.7,21.83 194.03,21.83
V5_V5A_DSW on BOTTOM (solid shape): 199.78,20.22 199.78,19.06 199.52,18.8 199.52,17.03 199.4,16.9 197.12,16.9 196.97,17.06 196.97,19.08 197.18,19.3 199.5,19.3 199.5,20.14 199.28,20.14 199.28,19.3 199,19.3 199,20.14 198.78,20.14 198.78,19.3 197.18,19.3 198.16,20.28 199.72,20.28
V5_V5A_DSW on BOTTOM (solid shape): 194.61,8.36 197.35,8.36 197.88,7.84 197.88,7.46 197.88,7.46 197.88,7.12 197.86,7.08 197.83,7.07 196.98,7.07 196.98,6.84 197.83,6.84 197.86,6.83 197.88,6.79 197.88,6.62 197.86,6.58 197.83,6.57 196.98,6.57 196.98,6.34 197.83,6.34 197.86,6.33 197.88,6.29 197.88,6.22 197.73,6.08 194.35,6.08 194.05,6.38 194.04,6.38 194.01,6.4 193.99,6.45 193.85,6.79 193.47,6.76 193.39,6.64 193.37,6.49 193.34,6.41 193.27,6.38 193.21,6.38 193.17,6.4 193.16,6.43 193.16,8.67 193.17,8.7 193.21,8.72 194.25,8.72
V5_V5A_DSW on IN1 (solid shape): 187.7,8.67 187.71,8.65 187.72,8.63 187.72,7.97 187.27,7.53 187.18,7.5 187.1,7.56 186.68,7.72 186.52,7.3 186.51,7.2 186.42,7.16 184.59,7.16 184.39,7.35 184.39,8.78 184.6,8.99 187.38,8.99
V5_V5A_DSW on IN1 (solid shape): outline of 346 points within 192.78,6.33 199.64,19.67
V5_V5A_DSW on IN2 (solid shape): outline of 411 points within 184.01,5.7 196.21,10.46
V5_V5A_DSW on SVCC (solid shape): 219.12,26.53 219.12,18.81 220.07,17.85 220.07,14.37 219.57,13.88 217.81,13.88 214.79,16.9 197.71,16.9 197.71,16.9 197.58,16.9 197.58,18.9 197.67,18.99 210.32,18.99 210.33,18.95 210.61,18.67 210.99,18.81 211.07,18.85 211.15,18.81 211.52,18.67 211.81,18.95 211.82,18.99 214.73,18.99 216.18,20.43 216.18,26.7 216.54,27.06 218.58,27.06
V5_V5A_DSW on IN4 (solid shape): outline of 2053 points within 49.68,29.94 60.78,59.58
V5A_DS3_SRC on TOP (solid shape): 54.37,58.48 54.37,56.52 51.84,53.98 51.84,49.89 51.56,49.61 47.24,49.61 47.01,49.84 47.01,54.91 45.92,56 45.92,57.29 46.03,57.29 46.03,57.65 46.37,58 52.7,58 53.31,58.61 54.25,58.61
V5A_DS3_VIN on TOP (solid shape): 62.39,51.95 62.39,49.75 62.5,49.64 62.99,49.64 63.1,49.53 63.1,49.04 63.05,48.99 59.43,48.99 57.59,50.83 57.59,51.61 57.82,51.84 60.81,51.84 61.12,52.15 62.19,52.15
V5A_DS3_VIN on BOTTOM (solid shape): 63.85,49.89 63.85,49.16 63.8,49.11 61.88,49.11 61.86,49.09 61.08,49.09 61.05,49.12 61.05,50.88 61.16,50.99 62.76,50.99
V6_V3.3A_DSW on TOP (solid shape): 72.71,38.25 72.71,36.24 72.63,36.16 71.27,36.16 71.04,36.39 71.04,38.12 71.99,38.12 71.99,38.33 72.63,38.33
V6_V3.3A_DSW on TOP (solid shape): outline of 213 points within 77.51,44.92 90.93,51.47
V6_V3.3A_DSW on TOP (solid shape): outline of 1064 points within 68.56,8.24 184.05,30.46
V6_V3.3A_DSW on BOTTOM (solid shape): 46.17,45.52 46.17,44.43 45.99,44.25 43.96,44.25 43.81,44.41 43.81,45.32 44.29,45.8 45.89,45.8
V6_V3.3A_DSW on BOTTOM (solid shape): 86.39,50.07 86.39,49.64 85.59,48.84 85.2,48.84 85.11,48.93 85.11,49.26 85.34,49.49 85.64,49.49 85.82,49.66 85.82,50.1 85.9,50.18 86.28,50.18
V6_V3.3A_DSW on BOTTOM (solid shape): 242.17,17.76 242.17,15.81 242.08,15.73 241.58,15.73 241.42,15.88 241.42,16.24 241.19,16.47 241.19,17.92 242.01,17.92
V6_V3.3A_DSW on BOTTOM (solid shape): 194.61,24.62 194.61,23.71 194.46,23.56 194.15,23.56 193.82,23.23 193.47,23.23 193.47,23.25 192.74,23.25 192.66,23.25 192.6,23.31 192.6,23.39 192.62,23.43 192.65,23.44 193.47,23.44 193.47,23.65 192.65,23.65 192.62,23.66 192.6,23.7 192.6,24.53 192.7,24.63 193.68,24.63 193.93,24.88 194.35,24.88
V6_V3.3A_DSW on BOTTOM (solid shape): 81.67,34.1 81.68,34.06 81.69,34.02 81.72,33.97 81.75,33.94 81.78,33.9 81.83,33.87 81.87,33.85 81.92,33.84 81.97,33.83 82.02,33.83 82.06,33.84 82.11,33.86 82.15,33.88 82.19,33.91 82.23,33.95 82.25,33.98 82.27,34 82.3,34.01 82.33,34.01 82.36,34 82.39,33.99 82.4,33.98 82.58,33.79 82.58,32.42 82.43,32.26 80.83,32.26 80.44,32.65 80.44,32.65 79.93,32.65 79.88,32.71 79.88,32.77 80.27,32.77 80.27,33.57 80.07,33.57 80.07,32.77 79.88,32.77 79.88,33.75 80.26,34.13 81.64,34.13
V6_V3.3A_DSW on BOTTOM (solid shape): outline of 167 points within 65.19,28.99 73.09,39.41
V6_V3.3A_DSW on IN1 (solid shape): outline of 657 points within 70.86,35.77 88.87,51.17
V6_V3.3A_DSW on IN2 (solid shape): 182.65,10.9 182.74,10.85 182.73,10.74 183,10.24 183.27,10.74 183.26,10.85 183.35,10.9 183.73,10.9 183.79,10.84 183.79,10.03 182.8,9.04 181.42,9.04 180.97,9.5 180.97,10.76 181.11,10.9
V6_V3.3A_DSW on IN3 (solid shape): 182.72,10.73 182.71,10.7 182.77,10.34 183.14,10.27 183.17,10.28 183.2,10.26 183.37,10.09 183.38,10.07 183.39,10.05 183.39,9.99 183.18,9.78 183.18,9.78 182.13,8.73 181.47,8.73 181.35,8.85 181.35,10.31 181.91,10.87 182.59,10.87
V6_V3.3A_DSW on IN3 (solid shape): outline of 134 points within 192.58,23.3 197.61,26.26
V6_V3.3A_DSW on IN3 (solid shape): outline of 704 points within 42.64,34.55 72.71,52.53
V6_V3.3A_DSW on IN4 (solid shape): outline of 90 points within 68.8,27.9 82.11,33.81
V6_V3.3A_DSW on IN4 (solid shape): outline of 890 points within 179.78,9.35 195.27,24.96
V7_V3.3A_PCH on TOP (solid shape): 85.88,42.37 85.88,42.18 86.07,42.18 86.18,42.08 86.86,42.08 86.94,42 86.94,40.88 86.81,40.76 84.42,40.76 84.3,40.88 84.3,42.67 84.43,42.8 85.45,42.8
V7_V3.3A_PCH on TOP (solid shape): 95.18,34.32 95.18,32.05 95.05,31.93 94.78,31.93 94.57,32.14 94.57,32.62 94.41,32.78 94.41,33.86 94.23,34.04 94.23,34.23 94.41,34.41 95.09,34.41
V7_V3.3A_PCH on TOP (solid shape): 104.9,45.46 104.9,44.91 104.78,44.62 104.9,44.32 104.9,43.7 104.82,43.63 104.52,43.63 104.5,43.64 103.97,43.64 103.7,43.91 101.9,43.91 101.77,43.78 101.77,39.18 101.72,39.13 101.37,39.13 101.32,39.18 101.32,39.41 101.27,39.45 100.96,39.45 100.88,39.53 100.88,39.89 100.88,39.92 100.91,39.94 100.91,42.4 101.04,42.53 101.04,43.01 100.4,43.64 100.4,44.1 100.41,44.11 100.44,44.21 100.41,44.31 100.4,44.33 100.4,44.52 100.45,44.57 101.75,44.57 102.08,44.9 103.8,44.9 103.86,44.95 103.86,45.46 103.93,45.53 104.82,45.53
V7_V3.3A_PCH on TOP (solid shape): 108.66,43.82 108.66,43.69 108.58,43.61 108.58,43.31 108.62,43.28 108.64,43.25 108.66,43.22 108.66,42.98 108.36,42.67 108.36,42.32 108.69,41.99 108.69,41.76 108.65,41.72 108.64,41.72 108.53,41.52 108.67,41.34 108.69,41.33 108.69,41.12 108.63,41.07 108.08,41.07 108.02,41.02 108.02,40.9 108,40.87 108,39.45 108.36,39.09 108.38,39.09 108.56,38.92 108.56,38.9 108.6,38.81 108.67,38.74 108.68,38.73 108.71,38.69 108.71,38.57 108.7,38.55 108.68,38.53 108.56,38.32 108.66,38.1 108.69,38.06 108.69,37.9 108.63,37.85 108.46,37.85 108.29,37.92 108.12,37.85 107.57,37.85 107.26,38.15 107.26,40.08 107.27,40.09 107.28,40.16 107.27,40.23 107.26,40.24 107.26,43.29 107.84,43.87 108.61,43.87
V7_V3.3A_PCH on BOTTOM (solid shape): 46.17,43.92 46.17,43.31 46.09,43.24 43.78,43.24 43.73,43.29 43.73,43.97 43.76,44 46.09,44
V7_V3.3A_PCH on BOTTOM (solid shape): 240.66,17.76 240.66,16.49 240.4,16.24 238.88,16.24 238.75,16.36 238.75,17.76 238.88,17.89 240.53,17.89
V7_V3.3A_PCH on BOTTOM (solid shape): 108.22,44 108.22,41.46 108.13,41.37 107.36,41.37 107.34,41.39 107.34,42.99 107.87,43.52 107.87,44.03 107.92,44.08 108.15,44.08
V7_V3.3A_PCH on BOTTOM (solid shape): 108.83,38.96 108.83,37.28 108.83,37.28 108.83,36.41 109.01,36.23 110.41,36.23 110.56,36.08 110.56,35.21 110.44,35.09 110.1,35.09 109.79,35.39 108.71,35.39 108.18,35.91 108.18,37.32 107.97,37.53 107.42,37.53 107.26,37.69 107.26,38.87 107.5,39.11 108.68,39.11
V7_V3.3A_PCH on BOTTOM (solid shape): 231.9,18.14 231.9,15.86 231.77,15.73 230.37,15.73 230.12,15.98 230.12,16.92 230.89,16.92 230.89,16.87 230.9,16.82 230.92,16.78 230.94,16.73 230.97,16.69 231,16.66 231.04,16.63 231.09,16.6 231.14,16.59 231.19,16.58 231.24,16.58 231.28,16.59 231.33,16.6 231.38,16.63 231.42,16.66 231.45,16.69 231.48,16.73 231.5,16.78 231.52,16.82 231.53,16.87 231.53,16.92 231.52,16.97 231.5,17.02 231.48,17.06 231.45,17.11 231.42,17.14 231.38,17.17 231.33,17.19 231.28,17.21 231.24,17.22 231.19,17.22 231.14,17.21 231.09,17.19 231.04,17.17 231,17.14 230.97,17.11 230.94,17.06 230.92,17.02 230.9,16.97 230.89,16.92 230.12,16.92 230.12,17.89 230.5,18.27 231.77,18.27
V7_V3.3A_PCH on IN1 (solid shape): outline of 524 points within 111.01,39.46 113.94,42.5
V7_V3.3A_PCH on IN2 (solid shape): 162.48,18.41 162.48,14.76 162.27,14.56 161,14.56 160.75,14.82 160.75,17.29 160.81,17.39 160.92,17.37 161.45,17.61 160.92,17.85 160.81,17.83 160.75,17.93 160.75,17.97 161.32,18.54 162.35,18.54
V7_V3.3A_PCH on IN3 (solid shape): outline of 1106 points within 84.32,37.68 113.25,52.17
V7_V3.3A_PCH on GND2 (solid shape): 108.18,39.05 108.18,37.81 108.18,37.79 108.06,37.67 107.4,37.67 107.3,37.78 107.29,37.79 107.29,37.81 107.29,39.03 107.39,39.14 108.1,39.14
V7_V3.3A_PCH on IN4 (solid shape): 162.41,19.31 162.41,18.24 162.07,17.9 161.26,17.9 161.13,17.93 161,17.9 160.95,17.9 160.73,18.13 160.73,19.29 160.98,19.54 162.17,19.54
V7_V3.3A_PCH on IN4 (solid shape): outline of 981 points within 100.96,28.23 108.22,42.56
V8_V1.8A on TOP (solid shape): 74.47,35.42 74.47,34.89 73.51,33.93 72.22,33.93 72.05,34.09 72.05,34.99 72.71,35.65 74.24,35.65
V8_V1.8A on TOP (solid shape): 85.01,55.85 85.03,55.78 85.08,55.66 85.14,55.54 85.21,55.43 85.28,55.31 85.37,55.21 85.46,55.11 85.55,55.02 85.6,54.97 85.83,54.76 85.83,54.12 85.71,54.01 85.42,54.01 85.09,54.35 83.94,54.35 83.87,54.42 83.87,54.78 83.68,54.96 83.47,54.96 83.38,55.06 83.4,55.17 83.77,55.17 83.77,55.97 83.57,55.97 83.57,55.17 83.4,55.17 83.4,55.97 83.51,56.07 84.78,56.07
V8_V1.8A on BOTTOM (solid shape): 110.5,41.39 110.5,41.22 108.53,39.25 107.43,39.25 107.33,39.35 107.33,39.62 107.63,39.92 107.84,39.92 109.35,41.42 110.46,41.42
V8_V1.8A on BOTTOM (solid shape): 85.19,55.46 85.37,55.2 85.75,54.83 85.75,54.16 85.63,54.04 85.1,54.04 84.82,54.32 84.14,54.32 83.96,54.51 83.96,55.41 84.01,55.46
V8_V1.8A on IN2 (solid shape): outline of 793 points within 72.64,33.97 89.91,55.51
V10_V1.2U on TOP (solid shape): 81.97,56.03 81.97,55.17 81.99,55.15 81.99,54.83 81.98,54.79 81.98,54.74 81.98,54.69 81.99,54.66 81.99,54.41 82.34,54.06 82.62,54.06 82.65,54.04 82.7,54.02 82.76,54.01 82.81,54 82.87,54 82.93,54.01 82.98,54.03 83.03,54.05 83.06,54.07 85.22,54.07 85.38,53.9 85.38,52.47 85.23,52.31 79.93,52.31 79.73,52.52 79.73,54.07 80.06,54.4 80.87,54.4 81.07,54.6 81.07,55.17 81.77,55.17 81.77,55.97 81.57,55.97 81.57,55.17 81.07,55.17 81.07,55.77 81.38,56.07 81.93,56.07
V10_V1.2U on TOP (solid shape): outline of 15666 points within 99.13,12.45 154.35,44.15
V10_V1.2U on BOTTOM (solid shape): outline of 192 points within 100.88,9.76 108.43,16.14
V10_V1.2U on BOTTOM (solid shape): outline of 10023 points within 97.28,9.76 155.75,42.76
V10_V1.2U on IN1 (solid shape): 86.14,53.61 86.14,52.58 86.11,52.56 86.11,52.48 86.11,52.43 85.75,52.07 85.53,52.05 85.36,51.91 85.28,51.87 85.19,51.91 84.63,51.98 84.65,51.42 84.68,51.31 84.59,51.24 82.05,51.24 81.96,51.31 81.99,51.42 82.08,51.89 81.62,52.05 81.03,52.05 80.88,52.08 80.74,52.04 80.63,52.14 80.63,53.1 81.34,53.81 85.94,53.81
V10_V1.2U on IN1 (solid shape): 123.54,37.59 123.54,37.32 123.46,37.24 119.59,37.24 119.58,37.24 119.51,37.26 119.43,37.24 119.42,37.24 116.03,37.24 116.01,37.24 115.99,37.25 115.88,37.37 114.96,37.37 114.93,37.38 114.91,37.42 114.91,37.59 114.98,37.66 117.11,37.66 117.12,37.66 117.22,37.6 117.32,37.6 117.37,37.6 117.43,37.66 117.73,37.66 117.76,37.65 117.81,37.6 117.83,37.6 117.9,37.59 117.97,37.6 118,37.6 118.05,37.65 118.39,37.65 118.47,37.6 118.55,37.59 118.66,37.6 118.72,37.66 119.01,37.66 119.1,37.57 119.3,37.57 119.36,37.63 119.51,37.34 119.72,37.59 119.78,37.59 119.79,37.59 119.86,37.58 119.93,37.59 119.94,37.59 119.99,37.59 119.99,37.6 120.04,37.6 120.12,37.67 120.33,37.67 120.39,37.61 120.41,37.61 120.5,37.59 120.58,37.61 120.59,37.61 120.61,37.61 120.66,37.67 121,37.67 121.06,37.6 121.15,37.6 121.25,37.6 121.32,37.67 122.34,37.67 122.35,37.67 122.42,37.65 122.49,37.67 122.5,37.67 123.24,37.67 123.46,37.67
V10_V1.2U on GND1 (solid shape): 120.37,37.64 120.5,37.59 120.62,37.64 120.66,37.66 120.78,37.66 120.85,37.66 121,37.66 121.03,37.64 121.15,37.6 121.27,37.64 121.3,37.66 121.37,37.66 121.51,37.66 121.51,37.66 121.66,37.66 121.66,37.66 121.9,37.66 121.9,37.66 122.64,37.66 122.64,37.66 122.83,37.66 122.83,37.66 122.96,37.66 122.96,37.66 123.19,37.66 123.19,37.66 123.4,37.66 123.48,37.58 123.48,37.45 123.41,37.38 123.38,37.34 123.36,37.32 123.28,37.24 122.68,37.24 122.63,37.19 122.22,37.19 122.11,37.23 121.99,37.19 121.55,37.19 121.46,37.21 121.38,37.19 121.23,37.19 121.18,37.14 120.96,37.14 120.82,37.21 120.68,37.14 120.32,37.14 120.18,37.21 120.04,37.14 120.01,37.12 119.73,37.12 119.63,37.22 119.63,37.37 119.68,37.42 119.71,37.47 119.75,37.52 119.76,37.53 119.94,37.53 120.08,37.68 120.34,37.68
V10_V1.2U on IN2 (solid shape): 118.96,37.72 118.96,37.46 118.77,37.27 117.55,37.27 117.55,37.32 117.29,37.57 117.02,37.32 117.02,37.27 116.24,37.27 115.95,37.27 115.82,37.39 115.82,37.71 115.85,37.75 118.93,37.75
V10_V1.2U on IN2 (solid shape): 123.31,37.71 123.31,37.29 123.26,37.24 121.29,37.24 121.22,37.17 121.08,37.17 121.02,37.22 120.64,37.22 120.58,37.17 120.39,37.17 120.34,37.22 120.06,37.22 119.96,37.12 119.75,37.12 119.65,37.22 119.65,37.39 119.71,37.47 119.72,37.55 119.71,37.6 119.68,37.65 119.67,37.76 119.76,37.81 123.21,37.81
V10_V1.2U on IN3 (solid shape): outline of 88 points within 115.78,36.1 123.28,38.22
V10_V1.2U on GND2 (solid shape): 123.56,33.56 123.56,33.1 123.51,33.05 122.6,33.05 122.52,33.13 122.52,34.07 122.63,34.17 122.96,34.17
V10_V1.2U on GND2 (solid shape): 123.42,37.58 123.42,37.35 123.31,37.24 121.45,37.24 121.33,37.12 121.33,36.84 121.28,36.78 119.58,36.78 119.5,36.86 119.5,37.49 119.54,37.5 119.61,37.52 119.66,37.57 119.67,37.6 119.99,37.6 120,37.57 120.16,37.49 120.32,37.57 120.34,37.6 120.65,37.6 120.66,37.57 120.82,37.49 120.98,37.57 121,37.6 121.28,37.6 121.3,37.57 121.46,37.49 121.62,37.57 121.63,37.6 121.94,37.6 121.95,37.58 122.11,37.5 122.26,37.58 122.28,37.6 122.58,37.6 122.6,37.58 122.75,37.5 122.91,37.58 122.92,37.6 123.01,37.6 123.14,37.73 123.27,37.73
V10_V1.2U on IN4 (solid shape): outline of 1070 points within 80.92,27.87 103.14,53.33
V10_V1.2U_AE27 on BOTTOM (solid shape): 112.54,56.2 112.54,55.39 111.7,54.54 111.58,54.54 111.38,54.74 111.38,54.95 111.98,55.55 111.98,55.61 111.98,55.62 111.98,56.18 112.07,56.27 112.47,56.27
V10_V1.2U_AE27 on IN3 (solid shape): 112.55,56.23 112.55,55.24 112.88,54.9 112.88,54.83 112.59,54.54 112.5,54.54 111.94,55.1 111.94,56.14 112.13,56.32 112.46,56.32
V11_V1.00A on TOP (solid shape): 113.37,41.67 113.37,41.41 113.3,41.33 113.04,41.33 112.84,41.13 112.84,40.3 112.79,40.24 112.67,40.24 112.61,40.3 112.61,41.46 112.61,41.64 112.64,41.64 112.69,41.69 113.35,41.69
V11_V1.00A on TOP (solid shape): 114.45,41.08 114.45,38.95 114.39,38.89 114.04,38.89 113.94,38.8 113.94,38.56 113.91,38.54 113.59,38.54 113.56,38.57 113.55,38.57 113.51,38.62 113.51,39.43 113.58,39.5 113.91,39.5 114.01,39.61 114.01,41.08 114.06,41.13 114.39,41.13
V11_V1.00A on TOP (solid shape): 108.71,45.14 108.71,45.04 108.63,44.97 108.63,44.8 108.62,44.75 108.63,44.7 108.63,44.56 108.71,44.48 108.71,44.36 108.63,44.28 108.48,44.28 108.41,44.35 108.19,44.35 108.05,44.49 108.05,44.74 107.89,44.89 107.89,45.27 108.15,45.52 108.32,45.52
V11_V1.00A on TOP (solid shape): 90.14,48.72 90.88,48.72 90.95,48.65 90.94,48.54 90.93,48.53 90.9,48.52 90.14,48.52 90.14,48.32 90.9,48.32 90.93,48.31 90.94,48.3 90.95,48.27 90.95,47.13 91.13,46.95 91.33,46.95 91.46,46.83 91.46,45.28 91.38,45.2 89.68,45.2 89.54,45.34 89.92,45.34 89.92,46.15 89.72,46.15 89.72,45.34 89.54,45.34 89.52,45.37 89.52,46.15 89.5,46.15 89.5,46.41 89.52,46.45 89.53,46.5 89.54,46.55 89.53,46.61 89.52,46.66 89.5,46.69 89.5,48.37 89.86,48.72 90.14,48.72
V11_V1.00A on TOP (solid shape): 112.42,46.06 112.42,45.27 112.66,45.04 112.83,45.04 113.03,45.24 113.03,46.03 113.11,46.1 114.29,46.1 114.39,46 114.39,45.8 114.34,45.74 113.6,45.74 113.45,45.59 113.45,45.2 113.61,45.04 114.31,45.04 114.43,44.92 114.43,43.58 114.33,43.48 113.58,43.48 113.53,43.53 113.53,43.89 113.39,44.03 113.28,44.03 113.2,44.11 113.02,44.11 112.98,44.11 112.77,44.11 112.69,44.03 112.68,44.03 112.44,43.79 112.44,43.59 112.37,43.52 111.63,43.52 111.58,43.57 111.58,43.93 111.64,43.99 112.35,43.99 112.55,44.19 112.55,44.5 112.36,44.69 111.73,44.69 111.63,44.79 111.63,46.08 111.67,46.12 112.37,46.12
V11_V1.00A on BOTTOM (solid shape): 114.65,48.57 114.65,47.71 114.55,47.61 111.47,47.61 111.37,47.71 111.37,48.5 111.5,48.62 114.6,48.62
V11_V1.00A on BOTTOM (solid shape): 60.83,35.47 60.83,35.06 61,34.88 61,31.94 60.65,31.58 59.72,31.58 59.53,31.77 59.53,35.52 59.74,35.73 60.57,35.73
V11_V1.00A on BOTTOM (solid shape): 78.46,34.13 78.46,32.76 78.4,32.71 78.32,32.71 78.28,32.72 78.27,32.76 78.27,33.57 78.07,33.57 78.07,32.76 78.05,32.72 78.02,32.71 76.97,32.71 76.35,33.33 76.35,33.35 76.41,33.54 76.35,33.73 76.35,34.23 76.47,34.36 78.23,34.36
V11_V1.00A on BOTTOM (solid shape): outline of 202 points within 102.2,40.57 112.19,59.5
V11_V1.00A on IN1 (solid shape): 62.47,36.78 62.47,36.35 62.41,36.26 62.31,36.27 61.7,35.98 62.31,35.69 62.41,35.71 62.47,35.61 62.47,33.91 62.24,33.68 59.83,33.68 59.58,33.92 59.58,36.76 59.92,37.1 62.15,37.1
V11_V1.00A on IN1 (solid shape): outline of 240 points within 111.25,42.88 114.32,46.16
V11_V1.00A on GND1 (solid shape): 112.41,45.8 112.41,45.34 112.87,44.88 113.27,44.88 113.42,44.74 113.42,44.36 113.29,44.24 112.6,44.24 112.36,44.48 112.17,44.48 111.92,44.24 111.91,44.23 111.5,44.23 110.85,44.88 110.85,45.9 111.05,46.09 112.11,46.09
V11_V1.00A on IN2 (solid shape): 61.71,35.89 61.96,35.63 62.31,35.69 62.41,35.71 62.47,35.61 62.47,34.93 60.97,33.42 59.94,33.42 59.58,33.77 59.58,35.66 59.85,35.93 61.7,35.93
V11_V1.00A on IN2 (solid shape): outline of 455 points within 111.01,38.69 114.4,46.17
V11_V1.00A on SVCC (solid shape): outline of 89 points within 56.92,28.49 114.01,47.91
V11_V1.00A on IN3 (solid shape): outline of 231 points within 109.42,43.27 114.34,48.04
V11_V1.00A on GND2 (solid shape): 114.5,41.38 114.5,39.61 114.13,39.24 113.87,39.24 113.71,39.4 113.71,39.56 113.96,39.81 113.96,40.44 113.71,40.7 113.71,40.85 113.99,41.13 113.99,41.33 114.12,41.46 114.42,41.46
V11_V1.00A on GND2 (solid shape): outline of 116 points within 110.61,43.49 114.5,46.44
V11_V1.00A on IN4 (solid shape): 112.04,48.42 112.04,48.41 112.16,48.29 112.16,46.26 112.04,46.13 110.71,46.13 110.56,46.29 110.57,46.54 110.58,46.56 110.6,46.58 110.62,46.59 110.65,46.6 110.68,46.6 110.73,46.58 110.77,46.56 110.81,46.56 110.84,46.56 110.88,46.57 110.92,46.59 110.95,46.61 110.97,46.64 110.99,46.67 111,46.71 111.01,46.75 111,46.79 111.31,46.79 111.31,46.76 111.32,46.72 111.34,46.68 111.37,46.65 111.4,46.63 111.43,46.61 111.47,46.6 111.51,46.6 111.55,46.61 111.59,46.62 111.62,46.64 111.65,46.67 111.67,46.7 111.68,46.74 111.69,46.77 111.69,46.81 111.68,46.85 111.67,46.89 111.65,46.92 111.62,46.95 111.59,46.97 111.55,46.98 111.51,46.99 111.47,46.99 111.43,46.98 111.4,46.96 111.37,46.94 111.34,46.91 111.32,46.87 111.31,46.83 111.31,46.79 111,46.79 111,46.8 111,47.48 111.21,47.69 111.21,48.43 111.34,48.55 111.91,48.55
V11_V1.00A on IN4 (solid shape): outline of 323 points within 102.64,43.29 111.5,45.68
V12_V0.85A on BOTTOM (solid shape): 113.05,42.53 113.53,42.53 113.79,42.27 113.79,41.88 113.69,41.79 112.57,41.79 112.49,41.87 112.49,42.68 112.57,42.76 112.82,42.76
V12_V0.85A on BOTTOM (solid shape): 159.26,34.34 159.26,33.24 159.25,33.24 159.25,32.45 159.04,32.24 158.76,32.24 158.76,32.24 158.24,32.24 158,32.48 158,33.84 158.31,34.15 158.58,34.42 159.17,34.42
V12_V0.85A on GND1 (solid shape): 113.51,42.58 113.51,41.76 113.43,41.69 112.64,41.69 112.49,41.84 112.49,42.55 112.67,42.73 113.35,42.73
V12_V0.85A on IN3 (solid shape): outline of 188 points within 110.89,35.57 114.5,42.79
V12_V0.85A on GND2 (solid shape): 112.92,42.78 113.53,42.17 113.53,41.79 113.4,41.66 112.72,41.66 112.47,41.92 112.47,42.68 112.57,42.78 112.85,42.78
V12_V0.85A on IN4 (solid shape): outline of 601 points within 141.4,27.52 159.51,34.47
V12_V0.85A on IN4 (solid shape): outline of 693 points within 110.2,34.65 113.15,42.81
VCCCOREG0 on TOP (solid shape): 118.37,45.97 118.37,43.09 118.31,43.02 118.03,43.02 117.98,43.08 117.98,43.08 117.98,45.93 118.1,46.06 118.28,46.06
VCCCOREG0 on TOP (solid shape): 119.36,45.98 119.36,43.07 119.29,43 119.01,43 118.96,43.05 118.96,43.06 118.96,45.93 119.09,46.06 119.27,46.06
VCCCOREG0 on BOTTOM (solid shape): 119.27,46.44 119.27,42.75 119.18,42.65 118.56,42.65 118.54,42.68 118.54,42.68 118.44,42.78 118.44,46.44 118.51,46.51 119.2,46.51
VCCCOREG0 on IN1 (solid shape): 118.36,45.97 118.36,43.04 118.46,42.94 118.86,42.94 118.94,43.03 118.94,45.98 119.01,46.04 119.25,46.04 119.32,45.98 119.32,42.9 119.14,42.73 118.84,42.73 118.71,42.77 118.59,42.73 118.03,42.73 117.97,42.78 117.97,45.98 118.05,46.06 118.11,46.06 118.12,46.05 118.13,46.06 118.27,46.06
VCCCOREG0 on IN3 (solid shape): outline of 185 points within 118.08,42.66 119.57,46.09
VCCCOREG0 on GND2 (solid shape): 119.33,45.85 119.4,45.82 119.45,45.77 119.45,45.65 119.32,45.51 119.27,45.51 119.16,45.41 119.16,45.11 119.17,45.04 119.19,44.97 119.2,44.95 119.27,44.86 119.36,44.79 119.36,44.79 119.42,44.74 119.42,44.71 119.45,44.67 119.45,44.45 119.42,44.4 119.42,44.39 119.16,44.14 119.16,43.22 119.33,43.05 119.41,43.03 119.45,42.98 119.45,42.78 119.45,42.76 119.44,42.74 119.42,42.72 119.42,42.68 119.33,42.6 118.33,42.6 118.31,42.6 118.23,42.68 118.22,42.75 118.18,42.82 118.18,42.94 118.22,43 118.22,43.04 118.24,43.07 118.3,43.13 118.38,43.13 118.77,43.24 118.76,43.65 118.73,43.72 118.76,43.78 118.77,44.19 118.38,44.3 118.34,44.3 118.31,44.33 118.28,44.39 118.23,44.44 118.22,44.44 118.18,44.5 118.18,44.61 118.22,44.68 118.23,44.82 118.28,44.86 118.82,45.12 118.27,45.36 118.24,45.39 118.23,45.44 118.23,45.54 118.19,45.63 118.18,45.65 118.18,45.73 118.22,45.79 118.28,45.83 118.31,45.84 118.58,46.11 119.06,46.11
VCCCOREG0 on IN4 (solid shape): 119.27,45.58 119.27,42.77 119.14,42.64 118.53,42.64 118.38,42.79 118.38,43.09 118.38,45.6 118.48,45.7 119.15,45.7
VCCCOREG1 on BOTTOM (solid shape): 119.25,42.42 119.25,39.58 119.23,39.55 119.23,39.05 119.15,38.97 118.49,38.97 118.44,39.02 118.44,42.43 118.48,42.48 119.2,42.48
VCCCOREG1 on IN1 (solid shape): 118.53,42.53 118.66,42.39 118.84,42.43 118.92,42.45 118.99,42.41 119.11,42.34 119.25,42.36 119.35,42.36 119.4,42.28 119.4,39.27 119.37,39.24 119.27,39.14 119.08,39.14 119.06,39.15 119.04,39.16 119,39.19 119,42.1 118.83,42.28 118.5,42.28 118.39,42.16 118.39,39.21 118.3,39.12 118.09,39.12 118.07,39.12 118.05,39.14 117.92,39.27 117.92,42.24 117.96,42.32 118.05,42.34 118.22,42.37 118.3,42.52 118.3,42.56 118.52,42.56
VCCCOREG1 on GND1 (solid shape): 119.18,42.17 119.26,42.15 119.49,41.92 119.53,41.86 119.53,41.68 119.49,41.61 119.49,41.59 119.47,41.55 119.36,41.55 119.31,41.49 119.3,41.46 119.29,41.43 119.28,41.4 119.24,41.38 119.22,41.37 119.17,41.23 119.2,41.08 119.24,40.99 119.24,40.85 119.23,40.83 119.2,40.8 119.16,40.77 119.16,40.52 119.24,40.48 119.29,40.42 119.3,40.4 119.3,40.34 119.29,40.31 119.22,40.25 119.18,40.2 119.17,40.09 119.18,39.99 119.29,39.87 119.31,39.82 119.38,39.74 119.41,39.73 119.54,39.61 119.53,39.43 119.47,39.34 119.45,39.29 119.28,39.12 119.12,39.12 119.1,39.14 119.02,39.14 118.93,39.16 118.85,39.14 118.52,39.14 118.44,39.15 118.36,39.14 118.06,39.14 118,39.2 118,39.78 118.11,39.89 118.23,39.89 118.27,39.87 118.31,39.85 118.43,39.73 118.45,39.72 118.49,39.69 118.54,39.64 118.6,39.57 118.8,39.57 118.82,39.59 118.82,39.59 118.94,39.7 118.94,39.72 118.94,41.55 118.94,41.55 118.94,41.58 118.84,41.68 118.84,41.9 118.89,41.98 118.9,42.08 118.91,42.13 118.96,42.15 119.12,42.15 119.14,42.16
VCCCOREG1 on IN3 (solid shape): 119.53,41.87 119.53,41.57 119.53,41.55 119.53,40.46 119.51,40.39 119.45,40.35 119.21,40.09 119.45,39.82 119.51,39.78 119.53,39.72 119.53,39.46 119.35,39.27 118.18,39.27 118.08,39.37 118.08,39.7 118.23,39.85 118.23,41.42 118.13,41.53 118.09,41.56 118.08,41.61 118.08,42.14 118.14,42.2 119.2,42.2
VCCCOREG1 on GND2 (solid shape): 119.14,42.18 119.18,42.18 119.42,41.95 119.42,41.92 119.45,41.88 119.45,41.71 119.35,41.6 119.29,41.6 119.21,41.52 119.16,41.41 119.16,41.02 119.18,41 119.2,40.99 119.2,40.97 119.2,40.89 119.2,40.87 119.18,40.85 119.16,40.83 119.16,40.46 119.2,40.42 119.2,40.33 119.2,40.31 119.18,40.29 119.16,40.27 119.16,39.91 119.39,39.69 119.42,39.68 119.46,39.64 119.5,39.53 119.46,39.42 119.41,39.38 119.39,39.37 118.28,39.37 118.26,39.38 118.2,39.46 118.18,39.5 118.18,39.55 118.19,39.58 118.22,39.65 118.22,39.69 118.23,39.71 118.3,39.78 118.3,41.53 118.3,41.57 118.19,41.71 118.18,41.74 118.18,41.79 118.19,41.82 118.22,41.88 118.22,42.07 118.24,42.09 118.33,42.18 118.55,42.18 118.63,42.18 119.05,42.18
VCCCOREG1 on IN4 (solid shape): 119.32,42.1 119.32,39.73 119.22,39.63 118.48,39.63 118.38,39.73 118.38,42.12 118.51,42.25 119.17,42.25
VCCGT on TOP (solid shape): 123.79,39.89 123.79,39.75 123.68,39.64 120.62,39.64 120.56,39.69 120.56,39.94 120.59,39.97 123.71,39.97
VCCGT on TOP (solid shape): 123.81,38.8 123.81,38.66 123.7,38.55 120.59,38.55 120.57,38.57 120.57,38.84 120.61,38.88 123.73,38.88
VCCGT on TOP (solid shape): 173.33,49.54 173.33,45.01 173.22,44.9 171.44,44.9 171.37,44.82 171.37,43.91 171.52,43.75 172.64,43.75 172.87,43.53 172.87,42.89 171.54,41.57 166.06,41.57 164.66,42.97 164.66,47.13 165.42,47.89 170.79,47.89 171.71,48.81 171.71,49.46 172.02,49.77 173.11,49.77
VCCGT on TOP (solid shape): outline of 372 points within 120.52,40.69 137.83,47.16
VCCGT on BOTTOM (solid shape): outline of 531 points within 120.85,38.06 174.5,49.76
VCCGT on IN1 (solid shape): 170.1,48.91 170.1,40.79 169.54,40.24 166.42,40.24 166.42,40.27 164.23,42.46 164.23,48.92 164.87,49.55 169.46,49.55
VCCGT on IN1 (solid shape): outline of 1323 points within 120.47,39.63 136.87,48.24
VCCGT on GND1 (solid shape): 121.05,39.06 121.25,39.06 121.33,39.13 121.5,39.13 121.52,39.13 121.56,39.09 121.6,39.07 121.64,39.03 121.64,38.85 121.71,38.78 121.83,38.78 121.84,38.77 121.94,38.75 122.04,38.77 122.05,38.78 122.12,38.78 122.17,38.83 122.17,38.88 122.2,38.95 122.21,39.01 122.22,39.05 122.26,39.06 122.33,39.08 122.41,39.13 122.43,39.13 122.46,39.13 122.48,39.13 122.52,39.09 122.56,39.07 122.6,39.03 122.6,38.93 122.63,38.9 122.63,38.89 122.88,38.73 123.13,38.9 123.36,39.13 123.5,39.13 123.53,39.12 123.61,39.04 123.69,39.01 123.71,39.01 123.85,38.88 123.85,38.62 123.77,38.55 120.57,38.55 120.49,38.62 120.49,38.73 120.5,38.75 120.56,38.85 120.59,38.94 120.59,38.95 120.75,39.11 120.85,39.11 120.93,39.13 120.97,39.13
VCCGT on GND1 (solid shape): 121.03,40.15 121.23,40.15 121.31,40.22 121.51,40.22 121.61,40.12 121.61,39.94 121.69,39.87 121.8,39.87 121.81,39.86 121.91,39.84 122.01,39.86 122.02,39.87 122.09,39.87 122.14,39.92 122.15,39.98 122.18,40.05 122.18,40.12 122.18,40.14 122.27,40.22 122.47,40.22 122.58,40.12 122.58,40.02 122.65,39.94 122.92,39.82 123.14,40.02 123.14,40.03 123.34,40.22 123.52,40.22 123.56,40.2 123.61,40.18 123.82,39.97 123.82,39.72 123.74,39.64 120.89,39.64 120.82,39.65 120.76,39.64 120.6,39.64 120.58,39.65 120.56,39.66 120.53,39.71 120.49,39.74 120.47,39.76 120.47,39.78 120.47,39.83 120.47,39.85 120.55,39.95 120.59,40.05 120.59,40.07 120.71,40.19 120.76,40.2 120.8,40.22 120.95,40.22
VCCGT on GND1 (solid shape): 121.05,42.38 121.25,42.38 121.33,42.46 121.53,42.46 121.64,42.36 121.64,42.18 121.71,42.1 121.76,42.1 121.77,42.1 121.91,42.06 122.04,42.1 122.05,42.1 122.12,42.1 122.17,42.15 122.18,42.34 122.3,42.46 122.5,42.46 122.6,42.36 122.6,42.26 122.67,42.18 122.93,42.06 123.15,42.24 123.15,42.25 123.36,42.46 123.51,42.46 123.52,42.45 123.57,42.42 123.62,42.41 123.64,42.41 123.84,42.2 123.84,41.95 123.77,41.87 122.59,41.87 122.42,41.93 122.25,41.87 121.74,41.87 121.6,41.87 121.59,41.88 121.43,41.93 121.28,41.88 121.26,41.87 121.09,41.87 120.66,41.87 120.59,41.87 120.56,41.88 120.54,41.91 120.52,41.95 120.49,41.99 120.49,42.18 120.73,42.42 120.8,42.46 120.97,42.46
VCCGT on GND1 (solid shape): 121.05,41.29 121.15,41.27 121.22,41.29 121.25,41.29 121.33,41.37 121.53,41.37 121.64,41.26 121.64,41.09 121.71,41.01 121.73,41.01 121.74,41 121.91,40.94 122.08,40.99 122.1,41.01 122.12,41.01 122.17,41.06 122.17,41.12 122.18,41.18 122.18,41.24 122.19,41.26 122.3,41.37 122.5,41.37 122.54,41.31 122.58,41.28 122.6,41.26 122.6,41.16 122.68,41.09 122.98,40.93 123.19,41.19 123.19,41.2 123.36,41.37 123.47,41.37 123.5,41.36 123.51,41.35 123.57,41.31 123.63,41.29 123.64,41.29 123.68,41.28 123.84,41.11 123.84,40.86 123.77,40.78 123.26,40.78 123.05,40.78 122.72,40.78 122.54,40.78 122.26,40.78 122.08,40.78 121.76,40.78 121.57,40.78 121.21,40.78 120.57,40.78 120.49,40.86 120.49,40.98 120.5,41 120.58,41.09 120.61,41.19 120.61,41.21 120.7,41.29 120.72,41.3 120.78,41.32 120.83,41.36 120.85,41.37 120.97,41.37
VCCGT on GND1 (solid shape): outline of 252 points within 120.52,42.65 128.42,45.86
VCCGT on IN2 (solid shape): 170.1,47.18 170.1,40.79 169.54,40.24 167.28,40.24 164.23,43.29 164.23,47.17 164.63,47.56 169.72,47.56
VCCGT on IN2 (solid shape): outline of 1146 points within 120.52,38.58 136.88,47.16
VCCGT on GND2 (solid shape): 121.03,40.17 121.23,40.17 121.31,40.25 121.51,40.25 121.61,40.15 121.61,39.97 121.69,39.89 121.76,39.89 121.77,39.89 121.91,39.84 122.06,39.89 122.07,39.89 122.09,39.89 122.14,39.94 122.14,39.97 122.15,39.98 122.18,40.06 122.18,40.14 122.19,40.16 122.2,40.18 122.28,40.25 122.47,40.25 122.58,40.15 122.58,40.05 122.63,39.99 122.63,39.99 122.91,39.82 123.15,40.04 123.15,40.06 123.34,40.25 123.57,40.25 123.82,39.99 123.82,39.74 123.64,39.56 121.04,39.56 121.02,39.57 120.91,39.63 120.77,39.65 120.75,39.66 120.64,39.77 120.64,40.15 120.75,40.25 120.95,40.25
VCCGT on GND2 (solid shape): 121.05,41.24 121.25,41.24 121.33,41.32 121.53,41.32 121.64,41.21 121.64,41.03 121.66,41.01 121.71,40.96 121.8,40.96 121.81,40.96 121.91,40.94 122.01,40.96 122.02,40.96 122.12,40.96 122.17,41.01 122.17,41.12 122.18,41.15 122.18,41.2 122.3,41.32 122.5,41.32 122.6,41.21 122.6,41.11 122.73,40.99 122.75,40.99 122.77,40.98 123.02,40.94 123.19,41.13 123.19,41.14 123.36,41.32 123.59,41.32 123.84,41.06 123.84,40.81 123.67,40.63 122.91,40.63 122.85,40.64 122.8,40.63 120.87,40.63 120.67,40.83 120.67,41.21 120.77,41.32 120.97,41.32
VCCGT on GND2 (solid shape): 120.98,45.78 121.15,45.66 121.36,45.71 121.42,45.73 121.48,45.71 121.52,45.69 121.56,45.67 121.94,45.37 122.22,45.75 122.27,45.77 122.31,45.8 122.33,45.81 122.4,45.81 122.41,45.79 122.48,45.71 122.56,45.67 122.9,45.37 123.22,45.68 123.22,45.7 123.34,45.81 124,45.81 124.21,45.6 124.22,45.58 124.25,45.5 124.3,45.44 124.3,45.3 124.12,45.13 121.17,45.13 120.98,45.32 120.98,45.33 120.91,45.47 120.77,45.54 120.76,45.54 120.66,45.64 120.66,45.72 120.75,45.81 120.95,45.81
VCCGT on GND2 (solid shape): 121.05,42.38 121.18,42.37 121.25,42.38 121.3,42.41 121.33,42.44 121.37,42.46 121.5,42.46 121.53,42.43 121.58,42.41 121.64,42.36 121.64,42.18 121.71,42.1 121.76,42.1 121.77,42.1 121.91,42.06 122.04,42.1 122.05,42.1 122.12,42.1 122.17,42.15 122.17,42.27 122.18,42.34 122.3,42.46 122.5,42.46 122.6,42.36 122.6,42.26 122.67,42.19 122.93,42.06 123.15,42.24 123.15,42.25 123.36,42.46 123.59,42.46 123.6,42.45 123.84,42.2 123.84,41.95 123.67,41.77 122.7,41.77 122.67,41.78 122.66,41.8 122.42,41.93 122.19,41.8 122.17,41.78 122.14,41.77 121.71,41.77 121.68,41.78 121.66,41.8 121.43,41.93 121.2,41.8 121.18,41.78 121.15,41.77 120.87,41.77 120.67,41.98 120.67,42.36 120.77,42.46 120.97,42.46
VCCGT on GND2 (solid shape): 121.03,44.62 121.23,44.62 121.3,44.68 121.33,44.69 121.46,44.69 121.5,44.67 121.54,44.63 121.59,44.61 121.58,44.52 121.61,44.44 121.61,44.41 121.63,44.4 122.03,44.25 122.24,44.63 122.23,44.66 122.27,44.69 122.47,44.69 122.57,44.59 122.58,44.49 122.59,44.47 122.95,44.23 123.24,44.57 123.23,44.59 123.34,44.69 123.5,44.69 123.55,44.67 123.55,44.66 123.61,44.6 123.67,44.57 123.69,44.57 123.82,44.44 123.82,44.19 123.79,44.15 123.72,44.12 123.65,44.15 123.36,44.22 123.13,44.04 123.12,44.01 122.16,44.01 122.09,44.02 122.02,44.01 121.17,44.01 120.98,44.2 120.97,44.21 120.91,44.32 120.8,44.39 120.79,44.39 120.66,44.52 120.66,44.6 120.71,44.66 120.77,44.67 120.81,44.69 120.95,44.69
VCCGT on GND2 (solid shape): 121.43,43.58 121.49,43.52 121.56,43.48 121.9,43.14 122.22,43.5 122.22,43.52 122.27,43.58 122.47,43.58 122.57,43.47 122.58,43.37 122.59,43.35 122.95,43.11 123.24,43.45 123.23,43.47 123.34,43.58 123.43,43.57 123.48,43.57 123.57,43.46 123.71,43.41 123.73,43.41 123.82,43.32 123.82,43.07 123.64,42.89 123.25,42.89 123.24,42.9 123.14,42.92 123.04,42.9 123.03,42.89 122.7,42.89 122.62,42.9 122.54,42.89 122.31,42.89 122.3,42.9 122.2,42.92 122.1,42.9 122.09,42.89 121.04,42.89 121.02,42.92 120.9,43.04 120.72,43.05 120.69,43.05 120.64,43.09 120.64,43.3 120.67,43.36 120.67,43.41 120.7,43.48 120.77,43.51 120.83,43.52 120.89,43.55 120.93,43.56 120.96,43.55 121.08,43.48 121.22,43.5 121.29,43.54 121.33,43.58
VCCGT on GND2 (solid shape): 121.53,39.14 121.56,39.1 121.62,39.07 121.64,39.05 121.64,38.88 121.67,38.84 121.67,38.8 121.78,38.8 121.82,38.78 121.95,38.75 122.08,38.79 122.09,38.8 122.12,38.8 122.17,38.85 122.17,38.88 122.2,38.94 122.21,39.01 122.26,39.06 122.35,39.09 122.57,39.09 122.6,39.06 122.6,38.95 122.61,38.94 122.62,38.93 122.87,38.73 123.13,38.91 123.14,38.94 123.28,39.07 123.36,39.16 123.51,39.16 123.54,39.14 123.54,39.13 123.61,39.04 123.72,39.01 123.74,39.01 123.84,38.9 123.84,38.65 123.67,38.47 122.94,38.47 122.89,38.52 122.26,38.52 122.21,38.51 122.15,38.5 122.08,38.51 122.04,38.52 121.79,38.52 121.77,38.51 121.66,38.47 121.56,38.51 121.54,38.52 121.28,38.52 121.26,38.51 121.16,38.47 121.05,38.51 121.04,38.52 120.82,38.52 120.67,38.67 120.67,39.05 120.72,39.11 120.75,39.12 120.86,39.11 120.96,39.15 120.99,39.14 121.07,39.07 121.2,39.06 121.32,39.13 121.33,39.15 121.36,39.16 121.49,39.16
VCCGT on IN4 (solid shape): outline of 3358 points within 120.91,38.52 170.17,58.96
VCCPLL_OC on BOTTOM (solid shape): 85.14,59.78 85.14,59.1 85.06,59.02 82.14,59.02 82.06,59.1 82.06,59.77 82.12,59.83 85.08,59.83
VCCPLL_OC_S2 on TOP (solid shape): 82.49,59.22 82.49,58.6 82.23,58.34 82.17,58.34 82,58.16 81.97,58.12 81.97,57.37 81.92,57.32 81.85,57.32 81.81,57.33 81.8,57.37 81.8,58.12 81.57,58.12 81.57,57.32 81.55,57.32 81.3,57.32 81.22,57.39 81.22,59.22 81.33,59.32 82.39,59.32
VCCPLL_OC_S2 on BOTTOM (solid shape): 81.8,59.72 81.8,58.97 81.82,58.95 81.82,58.88 81.89,58.88 81.96,58.81 82.4,58.81 82.47,58.74 82.47,58.18 82.42,58.13 81.19,58.13 80.68,58.65 80.68,59.63 80.83,59.78 81.74,59.78
VCCSA on TOP (solid shape): 152.95,55.54 152.95,51.15 152.75,50.94 152.31,50.94 152.14,50.77 152.14,50.69 152.14,50.69 152.14,50.18 152.14,50.18 152.29,50.03 152.72,50.03 152.9,49.85 152.9,48.22 152.74,48.06 152.72,48.05 152.7,48.05 151.1,48.06 151.08,48.07 151.06,48.08 150.51,48.7 149.93,48.7 149.68,48.95 149.67,51.02 149.68,51.03 150.37,53.29 149.74,55.57 149.73,55.59 149.74,55.62 150.26,56.15 152.34,56.15
VCCSA on TOP (solid shape): 117.06,46.73 117.06,46.7 116.82,46.46 116.82,46.38 116.69,46.26 116.57,46.26 116.45,46.14 116.45,45.6 116.52,45.53 116.78,45.53 116.82,45.49 116.82,45.28 116.78,45.24 116.5,45.24 116.4,45.14 116.4,44.53 116.45,44.48 116.78,44.48 116.82,44.45 116.82,44.11 116.77,44.07 116.44,44.07 116.37,43.99 116.37,43.42 116.44,43.36 116.75,43.36 116.82,43.29 116.82,43.01 116.75,42.95 116.47,42.95 116.39,42.87 116.39,42.32 116.45,42.25 116.75,42.25 116.82,42.19 116.82,41.86 116.75,41.8 116.47,41.8 116.38,41.71 116.38,41.16 116.44,41.11 116.75,41.11 116.82,41.05 116.82,40.77 116.75,40.71 116.53,40.71 116.44,40.62 116.44,40.01 116.47,39.98 116.74,39.98 116.82,39.9 116.82,39.64 116.77,39.6 116.51,39.6 116.41,39.5 116.41,39.12 116.34,39.05 116.09,39.05 116.01,39.12 116.01,41.78 116.09,41.87 116.09,42.76 116.01,42.85 116.01,45.15 116.1,45.24 116.1,46.11 116.09,46.11 116.09,46.16 116.25,46.32 116.38,46.32 116.56,46.5 116.56,46.79 116.5,46.85 116.5,46.96 116.57,47.03 116.76,47.03
VCCSA on TOP (solid shape): 141.72,56.21 141.72,53.85 141.64,53.75 141.52,53.8 139.57,53.35 141.52,52.9 141.64,52.95 141.72,52.85 141.72,52.18 141.34,51.8 139.17,51.8 137.71,53.25 137.71,56.24 138.02,56.55 141.38,56.55
VCCSA on BOTTOM (solid shape): 116.84,45.42 116.84,42.14 116.71,42.01 116.71,40.7 116.68,40.67 115.94,40.67 115.89,40.72 115.89,41.63 116.36,42.1 116.36,42.47 116.46,42.57 116.46,45.49 116.76,45.49
VCCSA on BOTTOM (solid shape): 152.98,59.55 152.98,52.07 152.66,51.75 150.46,51.75 149.98,52.23 149.98,55.44 148.37,57.04 144.26,57.04 143.05,55.84 142.99,55.84 141.38,54.23 141.14,54.23 141.13,54.23 140.59,54.38 140.06,54.23 138.37,54.23 137.09,55.51 130.97,55.51 130.73,55.62 130.49,55.51 130.2,55.51 129.87,55.84 119.86,55.84 117.47,53.45 117.47,52.2 116.05,50.78 115.44,50.78 115.31,50.91 115.31,51.42 115.26,51.46 115.26,51.55 115.17,51.55 114.69,52.04 114.69,59.57 114.9,59.78 152.75,59.78
