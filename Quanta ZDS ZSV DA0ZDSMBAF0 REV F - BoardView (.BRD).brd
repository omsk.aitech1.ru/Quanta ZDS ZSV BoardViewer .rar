# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVDD:
  vias: v4(226.43,11.77) v4(226.43,11.13) v4(230.24,11.79) v4(232.94,6.11) v4(232.94,5.48)
V0.85A_ENA: length 122.7
  IN3 w0.203: v8(158.3,18.9) 157.82,18.42 157.82,15.4 153.68,11.25 140.19,11.25 140,11.44 132.43,11.44 132.14,11.72 127.17,11.72 126.89,11.44 107.43,11.44 107.43,11.44 102.42,11.44 94.81,19.05 94.81,22.08 93.51,23.37 91.83,23.37 90.02,25.19 89.7,25.19 88.36,26.53 79.34,26.53 v8(78.84,27.03)
  IN4 w0.203: v8(72.89,45.78) 73.78,44.89 74.18,44.89 74.31,44.76 74.6,44.47 74.6,38.77 72.97,37.14 72.97,35.87 72.61,35.52 v8(72.61,33.31)
  BOTTOM w0.117: PR97.2 69.86,47.78 70.15,47.48 70.15,47.1 70.4,46.84 v4(70.53,46.84) 70.53,46.18 71.14,45.57 71.93,45.57 72.05,45.7 72.82,45.7 v8(72.89,45.78)
  BOTTOM w0.203: v8(72.61,33.31) 73.55,32.37 73.55,30.69 75.36,28.89 77.34,28.89 78.84,27.39 v8(78.84,27.03) ; PR264.1 v8(158.3,18.9)
V0P85A_VID0: length 64.6
  IN1 w0.071: v1(111.27,37.66) 111.27,37.78 111.12,37.93 111.12,38.4 111.25,38.53 111.25,38.96 110.9,39.32 v2(110.9,39.63)
  GND1 w0.127: v9(110.54,40.04) 110.9,39.68 v2(110.9,39.63)
  GND2 w0.127: v7(110.21,40.16) 110.34,40.04 v9(110.54,40.04)
  IN4 w0.071: v8(158.29,24.43) 157.33,24.43 155.09,26.68 148.46,26.68 147.39,27.74 124.2,27.74 124.2,27.74 123.68,27.74 123.34,28.07 122.07,28.07 121.9,27.91 112.38,27.91 109.94,30.35 109.94,36.06 109.42,36.58 109.42,39.63 109.95,40.16 v7(110.21,40.16)
V0P85A_VID1: length 68
  IN1 w0.06: 110.75,38.58 110.56,38.4 110.56,38.22 111.05,37.73 v1(111.05,37.29)
  IN1 w0.071: v2(110.56,39.63) 110.76,39.43 110.76,38.6 110.75,38.58
  GND1 w0.127: v2(110.56,39.63) 110.2,39.63 v9(110.15,39.68)
  GND2 w0.127: v9(110.15,39.68) v7(109.82,39.68)
  IN4 w0.071: v7(109.82,39.68) 109.55,39.41 109.55,36.73 110.08,36.2 110.08,30.41 112.44,28.05 121.74,28.05 121.97,28.29 124.4,28.29 124.81,27.88 147.45,27.88 148.5,26.83 155.13,26.83 157.24,24.72 158.34,24.72 158.54,24.52 158.54,20.96 v8(158.32,20.73)
V1.00A_SRC:
  vias: v4(55.37,35.49) v4(55.95,35.36) v4(58.85,35.44) v5(58.03,34.68) v5(58.03,33.94) v5(58.77,34.68) v5(58.77,33.94)
V1.00A_VIN:
  vias: v4(61.33,36.15) v5(62.07,35.98) v5(62.81,35.98) v5(63.55,35.98)
V1.00S_PG: length 14.6
  IN4 w0.071: v8(70.94,49.37) 70.06,48.49 69.32,48.49 68.84,48.01 68.84,47.38 68.65,47.18 67.69,47.18 67.35,46.85 67.35,46.06 68.02,45.4 68.02,44.58 67.52,44.09 67.44,44.09 67.28,43.93 66.95,43.93 66.77,43.75 66.77,43.4 67.24,42.92 67.24,41.27 67.01,41.04 v8(67.01,40.36)
  BOTTOM w0.117: v8(67.01,40.36) 67.01,40.35 66.65,40 PR151.1 66.49,39.77 66.52,39.74 PR157.1 ; PR91.2 70.7,49.13 v8(70.94,49.37)
V1.8A_SRC: length 2.2
  BOTTOM w0.203: v4(70.12,35.75) 69.75,35.37 PR173.2
  vias: v4(70.35,36.38)
V1.8U_2.5U_LSW: length 13.3
  IN4 w0.071: v8(76.17,49.75) 77.26,49.75 80.94,53.43 83.64,53.43 v8(83.84,53.64)
  BOTTOM w0.117: v8(76.17,49.75) v4(75.39,50.53) 75.02,50.53 73.68,49.18 PR94.2
V3.3A_DSW_VIN: length 15.4
  IN3 w0.254: v9(74.34,45.43) 75.64,44.13 75.64,40.71 v4(77.08,39.26)
  GND2 w0.203: v8(73.83,45.43) v9(74.34,45.43)
  BOTTOM w0.203: v8(73.83,45.43) 73.58,45.43 73.19,45.04 v4(72.82,45.04) 72.71,45.14 70.94,45.14 70.86,45.07 70.69,45.07 70.46,45.3 70.46,45.68 70.17,45.97 69.26,45.97 68.93,45.63 68.93,45.16 68.67,44.9 68.46,44.9 68.17,44.61 PR123.2
  vias: v4(79.37,40.75) v4(79.45,39.15)
V3.3A_PCH_LSW: length 19.7
  IN4 w0.071: v8(76.47,49.22) 77.49,49.22 78.4,50.13 80.61,50.13 81.25,49.49 83.67,49.49 86.13,47.03 v8(86.13,44.89)
  BOTTOM w0.117: v8(76.47,49.22) 76.5,49.24 76.5,50.22 75.81,50.91 74.95,50.91 73.3,49.26 v4(72.97,49.26) PR93.2
V3.3A_PCH_S2:
  vias: v4(86.35,43.87)
V4_VCCIO: length 101.2
  IN2 w0.381: v3(104.77,46.01) 105.4,46.64 v9(105.4,47.4) 105.4,47.99 104.67,48.72 104.67,54.3 108.15,57.77 v4(108.15,58.26)
  IN3 w0.203: v7(72.1,50.45) 71.85,50.7 71.85,52.1 69.41,54.54 69.41,58.97 70.25,59.81 106.86,59.81 107.96,58.71 107.96,58.45 v4(108.15,58.26)
  GND2 w0.381: v9(105.4,47.4) v7(105.91,47.4)
  IN4 w0.203: v8(71.57,48.3) 71.57,48.85 72.13,49.41 72.13,49.95 72.1,49.98 v7(72.1,50.45) ; v4(108.15,58.26) 109.05,58.26 109.16,58.15 112.82,58.15 113.13,58.45 116.07,58.45 119.96,54.57 v8(119.96,54.32)
  IN4 w0.381: 113.68,42.37 113.68,43.17 113.44,43.42 112.31,43.42 111.98,43.75 111.98,45.33 111.62,45.69 111.46,45.85 110.38,45.85 110.13,46.11 108.5,46.11 107.21,47.4 v7(105.91,47.4)
  BOTTOM w0.203: R175.2 123.3,48.77 123.74,49.22 123.74,50.86 122.68,51.92 122.68,53.13 v4(122.67,53.13) 121.48,54.32 v8(119.96,54.32) ; PR99.2 71.8,48.08 v8(71.57,48.3)
  vias: v1(114.22,43.16) v1(114.22,42.6) v1(114.72,43.16) v1(114.72,42.6) v1(114.72,42.07) v1(115.23,42.6) v1(115.23,42.07) v1(115.23,41.51) v1(115.23,40.37) v1(115.23,38.69) v1(115.26,40.93) v1(115.26,39.25) v1(115.39,38.28) v1(115.68,38.03) v1(115.98,38.27) v1(116.61,38.27) v1(117.28,38.27) v1(117.92,38.28) v1(118.57,38.28) v1(119.2,38.27) v1(119.87,38.27) v1(121.14,38.27) v1(121.79,38.27) v1(122.44,38.27) v1(123.09,38.27) v2(114.22,43.16) v2(114.22,42.6) v2(114.72,43.16) v2(114.72,42.6) v2(114.72,42.07) v2(115.23,42.6) v2(115.23,42.07) v2(115.23,41.51) v2(115.23,40.37) v2(115.23,38.69) v2(115.26,40.93) v2(115.26,39.25) v2(115.39,38.28) v2(115.68,38.03) v2(115.98,38.27) v2(116.61,38.27) v2(117.28,38.27) v2(117.92,38.28) v2(118.57,38.28) v2(119.2,38.27) v2(119.87,38.27) v2(121.14,38.27) v2(121.79,38.27) v2(122.44,38.27) v2(123.09,38.27) v3(114.22,43.16) v3(114.22,42.6) v3(114.72,43.16) v3(114.72,42.6) v3(114.72,42.07) v3(115.23,42.6) v3(115.23,42.07) v3(115.23,41.51) v3(115.23,40.37) v3(115.23,38.69) v3(115.26,40.93) v3(115.26,39.25) v3(115.39,38.28) v3(115.68,38.03) v3(115.98,38.27) v3(116.61,38.27) v3(117.28,38.27) v3(117.92,38.28) v3(118.57,38.28) v3(119.2,38.27) v3(119.87,38.27) v3(121.14,38.27) v3(121.79,38.27) v3(122.44,38.27) v3(123.09,38.27) v5(50.21,34.53) v5(50.41,35.47) v5(50.96,34.52) v5(51.7,34.52) v7(115.03,42.32) v7(114.95,41.51) v7(115.01,40.29) v7(114.95,39.89) v7(115.98,38.2) v7(116.61,38.25) v7(118.13,38.16) v7(118.65,38.13) v7(119.01,38.11) v7(119.37,38.03) v7(119.7,38.03) v7(119.88,38.36) v7(120.07,38.03) v7(120.34,38.01) v7(120.88,38.05) v7(121.36,38) v7(121.63,38.01) v7(122.01,38.01) v7(122.27,38.01) v7(122.55,38) v7(122.83,38.02) v8(115.03,42.32) v8(114.95,41.51) v8(115.01,40.29) v8(114.95,39.89) v8(115.64,38.18) v8(115.98,38.2) v8(116.61,38.25) v8(118.13,38.16) v8(118.65,38.13) v8(119.01,38.11) v8(119.37,38.03) v8(119.7,38.03) v8(119.88,38.36) v8(120.07,38.03) v8(120.34,38.01) v8(120.88,38.05) v8(121.36,38) v8(121.63,38.01) v8(122.01,38.01) v8(122.27,38.01) v8(122.55,38) v8(122.83,38.02) v9(114.98,41.84) v9(115.04,41.18) v9(115.01,40.64) v9(115.01,38.97) v9(115.08,39.56) v9(116.3,38.11) v9(116.96,38.16) v9(117.6,38.16) v9(119.54,38.32) v9(120.23,38.34) v9(120.64,38.27)
V4_VCCIO_PG_IC: length 24.2
  TOP w0.203: v4(57.04,44.1) 57.5,43.64 PR33.2 PR32.1
  IN3 w0.203: v4(57.04,44.1) 56.59,44.55 56.59,46.31 57.15,46.87 57.15,48.71 59.99,51.54 63.11,51.54 64.62,50.04 68.03,50.04 68.11,49.96 68.38,49.96 68.6,49.74 70.61,49.74 70.95,50.08 71.58,50.08 v8(71.84,49.83)
  BOTTOM w0.117: v4(56.38,44.43) 56.71,44.1 v4(57.04,44.1)
V4_VCCIO_VCCSENSE: length 3.4
  GND1 w0.127: v9(114.5,38.44) 114.72,38.67 v2(114.72,38.69)
  GND2 w0.127: v8(114.67,38.06) 114.67,38.13 114.5,38.31 v9(114.5,38.44)
  BOTTOM w0.117: v8(114.67,38.06) 114.67,37.14 v4(114.98,36.84) 114.89,36.75 PR169.1
V4_VCCIO_VSSSENSE: length 4.5
  GND1 w0.254: v2(114.72,39.25) 114.67,39.25 v9(114.29,38.87)
  GND2 w0.127: v9(114.29,38.87) 114.31,38.85 v8(114.62,38.85)
  BOTTOM w0.117: v8(114.62,38.85) 114.62,38.54 114.4,38.31 114.4,36.79 v4(113.84,36.23) PR168.1
V5_V5A_DS3: length 78.1
  TOP w0.508: v4(172.11,31.74) 172.11,29.61 174.14,27.57 176.9,27.57 177.57,28.24 177.57,28.48 v5(178.05,28.97)
  IN1 w0.508: v4(164.48,35.01) 164.04,35.46 164.04,39.37 159.53,43.87 159.53,45.91 161.46,47.84 161.46,52.74 159.1,55.1 156.26,55.1 v5(155.7,55.66)
  IN2 w0.508: v5(178.05,28.97) 180.96,26.06 183.97,26.06 184.72,26.8 v4(185.11,26.8)
  IN3 w0.508: v4(193.41,18.4) 193.41,19.16 193.03,19.54 191.51,19.54 189.48,21.57 v4(189.48,25.64)
  IN4 w0.508: v4(185.11,26.8) 187.93,26.8 189.1,25.64 v4(189.48,25.64)
  BOTTOM w0.203: PU12.18 177.32,28.11 177.54,28.32 ; 169.68,31.74 167.9,29.96 167.9,25.95 168.47,25.38 PR224.1
  BOTTOM w0.508: v4(164.48,35.01) 166.41,35.01 169.68,31.74 v4(172.11,31.74)
  vias: v5(191.33,7.98) v5(191.71,7.35) v5(192.09,7.98) v5(192.48,7.35)
V5_V5A_DS3_PG: length 244.1
  TOP w0.203: v4(186.81,5.7) 186.81,2.78 187.19,2.39 196.97,2.39 197.86,3.28 197.86,7.47 200.65,10.27 200.65,13.22 200.76,13.32 v4(200.76,13.44) 200.76,13.93 201.29,14.46 201.29,19.41 200.65,20.05 198.37,20.05 197.99,20.43 197.99,21.47 v4(197.33,22.13)
  IN3 w0.203: v4(196.84,36.3) 196.2,35.66 196.2,32.42 197.87,30.75 197.87,22.67 v4(197.33,22.13) 196.89,21.7 196.89,21.14 197.22,20.81 197.22,20.05 191.84,14.66 183.34,14.66 182.12,13.44 174.66,13.44 171.06,17.05 168.35,17.05 165.66,19.74 161.31,19.74 160.09,18.52 160.09,17.87 159.39,17.17 159.39,14.75 154.33,9.68 145.32,9.68 144.88,9.24 139.83,9.24 139.79,9.28 139.2,9.87 131.78,9.87 131.49,10.15 127.82,10.15 127.54,9.87 101.75,9.87 93.08,18.54 v7(93.08,20.36) ; v7(66.54,39.56) 66.7,39.72 70.38,39.72 70.73,39.36 72,39.36 72.33,39.69 72.33,39.8 v8(72.59,40.05)
  IN4 w0.203: v8(65.68,46.09) 65.63,46.04 65.63,43.21 65.97,42.87 65.97,40.14 v7(66.54,39.56) ; v7(93.08,20.36) 93.08,22.77 92.75,23.1 89.96,23.1 88.54,24.52 88.54,25.13 82.95,30.72 82.95,34.07 82.24,34.78 79.46,34.78 78.52,35.71 76.54,35.71 v8(76.3,35.47)
  BOTTOM w0.203: PR109.2 66.87,46.15 66.32,46.15 66.27,46.09 PR110.1 v8(65.68,46.09) ; v4(200.76,13.44) 201.14,13.06 202.43,13.06 202.76,12.73 203.52,12.73 204.46,11.79 PQ28.2 206.11,11.79 206.14,11.82 PR510.1 ; v4(196.84,36.3) 196.97,36.18 198.68,36.18 199.32,36.81 200.27,36.81 200.43,36.97 PR337.1 201.67,36.56 201.8,36.43 PQ19.2 ; PQ16.2 182.87,3.28 184.17,4.58 PR316.1 184.17,5.6 184.4,5.82 186.68,5.82 v4(186.81,5.7) ; v8(72.59,40.05) PR149.1 72.83,39.83 72.97,39.83 73.05,39.76 73.07,39.76 73.35,39.48 73.35,39.16 74.68,37.83 75.05,37.83 v4(75.18,37.7) 76.3,36.58 v8(76.3,35.47)
V5_V5A_DS3_R:
  vias: v4(187.06,8.11)
V5_V5A_DSW: length 60.9
  TOP w0.203: v4(60.5,44.38) PR43.1
  TOP w0.508: v4(219.12,14.64) 220.64,14.64 221.61,15.6 221.61,16.36 219.45,18.52 v4(219.45,23.35) 219.45,24.11 v4(217.67,25.89)
  IN1 w0.508: v5(186.18,8.21) 186.18,9.63 187.45,10.9 v4(187.45,11.92)
  IN2 w0.508: v4(219.12,14.64) 218.9,14.85 215.37,14.85 214.99,15.23 203.41,15.23 201.39,17.25 v4(198.49,17.25)
  IN3 w0.508: v4(189.53,26.31) 189.69,26.31 190.87,25.13 190.87,21.44 191.89,20.43 v4(193.34,20.43)
  BOTTOM w0.254: v4(217.67,25.89) 217.9,25.66 R121.1 218.31,25.66 U18.2 ; v4(219.12,14.64) 219.17,14.58 219.17,14.08 R117.1 218.92,14.05 218.74,13.87 218.74,13.49 218.97,13.26 219.99,13.26 220.32,12.94 220.72,12.94 220.97,13.19 U16.2
  BOTTOM w0.508: C946.1 C945.2 217.67,27.02 v4(217.67,25.89) ; PD10.2 186.94,12.68 187.45,12.17 v4(187.45,11.92) ; PD12.2 v4(189.53,26.31)
  vias: v4(55.24,59.24) v4(56.76,57.08) v4(60.47,28.68) v4(94.41,14.33) v4(133.17,7.07) v4(193.92,20.81) v4(193.92,20.17) v4(197.86,18.52) v4(197.86,17.89) v4(197.86,17.25) v4(198.49,18.52) v4(198.49,17.89) v5(52.37,31.05) v5(52.88,30.29) v5(53.11,31.03) v5(53.61,30.27) v5(53.92,31.03) v5(54.43,30.27) v5(56.53,59.19) v5(56.53,58.43) v5(57.3,59.19) v5(57.3,58.43) v5(57.27,57.67) v5(58.03,57.67) v5(58.06,59.19) v5(58.06,58.43) v5(184.7,8.19) v5(184.7,7.45) v5(185.44,8.21) v5(185.44,7.47) v5(186.18,7.47) v5(193.52,7.96) v5(193.54,7.22) v5(194.25,7.98) v5(194.28,7.22) v5(195.07,7.22) v5(195.83,7.22)
V5A_DS3_SRC:
  vias: v4(46.83,56.19) v4(47.8,50.99)
V5A_DS3_VIN:
  vias: v4(59.61,49.97) v4(60.88,51.59) v4(61.33,50.63) v4(62.07,50.65)
V6_V3.3A_DSW: length 485.2
  TOP w0.203: v4(51.2,46.51) PR22.1 ; v4(49.83,43.01) 50.24,42.6 50.87,42.6 PR39.1 ; R90.1 104.7,39.53 104.31,39.15 104.31,38.85 v2(103.91,38.45) ; PR10.1 66.54,52.57 66.8,52.82 67.61,52.82 v4(68.12,52.31) ; PR32.2 v4(58.41,42.65) PR38.2
  TOP w0.279: R115.2 99.08,35.34 v4(99,35.26)
  TOP w0.508: 199.4,61.45 LED2.2 ; 199.4,61.45 LED4.2 ; 199.4,61.45 199.74,61.45 200.3,60.89 200.3,56.67 v4(199.51,55.89) ; LED1.2 189.99,61.45 LED3.2 188.35,61.45 LED6.3 v4(187.4,57.42) 186.63,56.65 177.91,56.65 177.39,57.16 LED5.3 ; v4(252.24,15.26) 250.62,16.87 249.55,16.87 248.66,15.98 v4(241.78,15.98) 241.67,15.98 240.53,14.84 230.5,14.84 229.36,15.98 225.63,15.98 221.94,12.3 219.58,12.3 215.51,16.36 215.51,21.83 v4(214.62,22.72) 214.29,23.05 198.4,23.05 v4(196.87,24.58) v4(196.87,25.24) ; v4(216.15,27.41) 217.93,27.41 218.94,28.43 221.98,28.43 224.16,26.25 v4(226.63,26.25) 227.18,26.25 229.23,28.3 234.69,28.3 v4(236.34,26.65)
  IN1 w0.508: v4(157.55,27.39) 157.55,27.24 158.22,26.56 159.26,26.56 160.24,25.59 162.05,25.59 163.59,24.04 163.61,24.04 163.73,23.93 163.96,23.93 v4(164.41,23.48) ; v4(56.31,24.26) 57.12,23.45 61.56,23.45 v4(61.97,23.05) 62.15,22.87 62.15,21.4 61.72,20.97 61.72,14.16 63.11,12.77 77.77,12.77 v4(78.66,11.88)
  GND1 w0.254: v2(67.52,44.73) 67.51,44.72 67.49,44.72 v9(67.13,44.37) ; v2(103.91,38.45) 104.07,38.28 105.43,38.28 105.7,38.02 v9(105.7,37.43)
  IN2 w0.254: v9(67.38,49.32) 67.38,51.58 v4(68.12,52.31)
  IN3 w0.254: v8(66.52,38.93) 66.14,39.31 66.14,40.2 66.64,40.71 66.64,42.36 66.97,42.69 66.97,44.03 67.13,44.19 v9(67.13,44.37) 67.13,45.25 67.4,45.52 67.4,47.43 66.63,48.2 66.63,48.64 66.86,48.88 66.94,48.88 v9(67.38,49.32) ; v4(99,35.26) 99.1,35.16 99.59,35.16 99.96,35.54 103.51,35.54 105.4,37.43 v9(105.7,37.43)
  IN3 w0.508: v4(172.84,10.62) 172.84,11.54 170.96,13.42 v4(169.69,13.42) ; v4(42.28,55.99) 43.3,54.97 43.3,52.43 ; 194.41,26.04 192.58,27.87 189.33,27.87 188.31,26.86 188.31,22.89 187.6,22.18 187.6,19.74 186.15,18.3 182.29,18.3 181.3,17.3 181.3,16.09 180.49,15.27 175.3,15.27 173.52,17.06 173.52,19.4 172.46,20.45 169.01,20.45 165.98,23.48 v4(164.41,23.48) ; v7(108.72,27.37) 108.73,27.36 v7(109.57,27.36) 110.62,28.42 v7(112.68,28.42) v7(113.19,28.42) ; v4(86.84,33.79) 86.2,33.79 85.9,33.48 v5(81.71,33.48) ; v4(157.55,22.64) v4(157.55,27.39)
  GND2 w0.254: v8(67.64,49.62) 67.64,49.57 v9(67.38,49.32) ; v8(66.78,44.11) 66.9,44.11 67.13,44.34 v9(67.13,44.37) 66.83,44.67 v8(66.42,44.67)
  IN4 w0.203: v5(72.36,38.01) 73.12,38.01 74.33,39.22 74.33,44.32 v8(74.06,44.59)
  IN4 w0.254: 81.35,28.13 82.19,27.29 v8(82.19,25.1)
  IN4 w0.508: 191.15,55.89 191.15,55.2 191.59,54.77 191.59,53.86 191.36,53.63 191.36,52.13 194.63,48.85 194.63,46.08 192.68,44.13 192.68,34.63 193.41,33.89 193.41,29.83 194.25,28.99 194.25,27.85 v4(196.87,25.24) ; 191.15,55.89 v4(199.51,55.89) ; 191.15,55.89 190.63,56.41 189.31,56.41 188.3,57.42 v4(187.4,57.42) ; v4(157.55,27.39) 157.35,27.19 150.31,27.19 149.32,28.18 147.77,28.18 147.69,28.25 141.51,28.25 141.12,28.64 113.42,28.64 v7(113.19,28.42) v7(112.68,28.42) ; v4(61.97,23.05) 62.4,23.05 62.98,23.63 63.27,23.63 63.81,24.16 67.71,24.16 68.37,24.82 68.37,26.73 68.75,27.11 68.75,27.69 69.22,28.15 ; v7(109.57,27.36) 108.73,27.36 v7(108.72,27.37) 107.73,27.37 107.23,27.87 105.4,27.87 102.46,30.82 100.53,30.82 100.2,31.15 100.2,34.3 99.23,35.26 v4(99,35.26)
  BOTTOM w0.203: v4(172.84,10.62) 172.84,10.14 173.22,9.76 174.49,9.76 174.62,9.63 174.62,7.86 175.1,7.38 R10930.2 175.1,6.15 175.02,6.08 C703.2 175.02,4.89 174.4,4.27 174.4,3.23 174.33,3.16 174.33,2.91 174.6,2.64 PR306.2 ; v4(99,35.26) 101.21,37.47 R503.1 ; v4(157.55,22.64) 157.83,22.92 PR236.1 PR243.1 ; PR117.1 66.87,44.9 66.65,44.9 v8(66.42,44.67) ; PR222.2 164.55,24.55 164.69,24.42 PR233.2 164.69,23.88 164.41,23.61 v4(164.41,23.48) ; PR121.1 50.69,43.87 v4(49.83,43.01) ; v4(68.12,52.31) 68.81,51.62 70.86,51.62 71.21,51.97 PR68.2 ; PR220.2 56.97,24.92 PR223.2 ; R860.2 170.2,12.76 169.69,13.27 v4(169.69,13.42) ; 70.45,38.93 70.45,39.92 70.58,40.05 PR148.1 ; v8(74.06,44.59) 74.09,44.62 74.43,44.62 74.72,44.91 PR119.1 PR104.1 ; v8(82.19,25.1) 82.19,24.16 82.39,23.96 R290.1 ; PR88.2 68.53,49.21 68.12,49.62 v8(67.64,49.62)
  BOTTOM w0.254: PR205.1 157.63,27.31 v4(157.55,27.39)
  BOTTOM w0.279: v4(216.15,27.41) 216.4,27.16 Q26.2 Q26.5 216.4,23.38 216.56,23.22 R399.1 R414.1 R416.1
  BOTTOM w0.381: v4(58.41,42.65) 57.6,43.47 56,43.47 54.48,44.99 52.39,44.99 51.2,46.18 v4(51.2,46.51)
  BOTTOM w0.406: R311.1 236.87,27.74 R10989.1 236.87,27.02 236.49,26.65 v4(236.34,26.65) ; R10985.1 226.48,26.41 v4(226.63,26.25)
  BOTTOM w0.508: v4(252.24,15.26) 251.8,14.81 R393.1 ; v4(99,35.26) 98.82,35.08 94.1,35.08 92.2,33.18 87.45,33.18 v4(86.84,33.79) ; v4(164.41,23.48) 164.41,23.35 164.64,23.12 165.09,23.12 165.53,22.69 165.53,20 169.55,15.97 169.55,13.56 v4(169.69,13.42) ; v4(216.15,27.41) 214.88,27.41 214.37,26.91 Q25.2 214.37,22.97 v4(214.62,22.72) 215.25,22.09 R10987.1 ; PR223.2 56.31,24.92 v4(56.31,24.26)
  vias: v4(45.05,45.65) v4(66.49,36.72) v4(66.49,36.06) v4(66.72,29.45) v4(68.55,37.32) v4(77.95,48.62) v4(84.27,48.62) v4(85.39,49.16) v4(88.69,50.1) v4(181.6,9.66) v4(181.76,10.29) v4(182.24,9.66) v4(182.42,10.55) v4(182.77,10.01) v4(192.86,24.29) v4(193.49,24.29) v4(193.92,23.82) v4(194.05,24.62) v5(69.04,29.29) v5(69.43,29.98) v5(69.79,29.32) v5(70.17,29.99) v5(70.54,29.32) v5(70.91,29.97) v5(71.62,36.67) v5(72.4,37.28) v5(72.38,36.53) v5(80.97,33.48) v5(81.02,32.75) v5(81.76,32.75) v5(85.87,48.19) v5(86.35,48.78) v5(86.89,49.32) v5(87.62,49.32) v5(88.44,48.38) v5(88.46,47.59)
V6_V3.3A_DSW_PG: length 51.4
  GND1 w0.06: v9(72.18,43.88) 72.18,44.08 v2(72.03,44.24)
  GND2 w0.127: v8(72.99,43.75) 72.33,43.75 72.21,43.88 v9(72.18,43.88)
  IN4 w0.071: v8(53.89,8.46) 54.1,8.67 54.1,9.46 54.96,10.32 55.6,10.32 57.22,11.94 57.22,13.95 57.59,14.33 57.59,19.45 58.14,20 58.14,21.14 59.35,22.35 59.35,22.84 63.1,26.59 63.34,26.59 63.58,26.35 64.79,26.35 65.4,26.96 65.4,27.81 69.15,31.57 70.48,31.57 70.86,31.95 70.86,32.93 70.33,33.46 70.33,34.81 70.6,35.08 70.6,37.68 71.57,38.65 71.57,38.66 72.81,39.9 72.81,40.2 73.05,40.43 73.58,40.43 73.73,40.58 73.73,42.03 73.35,42.41 73.35,43.4 v8(72.99,43.75)
  BOTTOM w0.117: v4(74.16,45.88) 74.27,45.78 PR119.2 73.7,45 72.99,44.29 v8(72.99,43.75)
V7_V3.3A_PCH: length 389.1
  TOP w0.203: v2(102.43,37.52) 102.31,37.4 R10970.2 ; U2.5 99.87,51.72 99.69,51.9 v4(99.69,52.33) v4(100.44,53.08) 100.69,53.33 104.38,53.33 104.85,53.8 108.53,53.8 109.4,52.94 R33.2 R34.2 ; PR13.1 69.67,51.88 v4(69.92,52.14) ; 103.78,43.92 103.73,43.87 103.73,42.88 103.98,42.63 103.98,42.2 103.73,41.95 R10968.2 ; v1(99.71,38.44) 99.71,39.05 99.81,39.15 R104.2 99.81,39.69 v4(99.28,40.22) 99.28,40.27 v4(99.71,40.7) 99.77,40.75 R76.1 99.75,41.26 R77.1 ; v4(46.68,33.54) 46.68,32.11 47.16,31.63 50.16,31.63 50.67,31.13 50.67,25.1 51.21,24.56 53.59,22.18 v4(54.1,22.18) ; v4(105.56,50.83) 105.4,50.99 R38.1 ; R10967.2 R10966.2 99.71,42.81 100.53,43.62 ; R10969.2 107.7,52.91 107.36,53.25 105.89,53.25 105.71,53.07 105.71,52.76 105.46,52.52 R10971.1 105.77,52.05 106.11,52.05 v4(106.32,51.85) 106.32,52.33 R29.1 ; R46.2 104.16,49.26 v4(104.13,49.28) 103.85,49 R10972.1 ; R61.2 R67.2 96.29,42.27 96.59,41.97 C13.2 96.97,41.64 97.18,41.43 v4(97.18,40.99)
  TOP w0.254: v2(111.27,39.59) 111.49,39.81 U3.AN15
  IN1 w0.203: v1(99.71,38.44) 99.71,37.02 98.5,35.8 98.5,34.68 v1(98.8,34.37)
  GND1 w0.203: v2(107.92,43.19) 107.92,43.53 v9(107.93,43.54) ; v2(113.26,40.92) 113.26,40.88 v9(113.03,40.64) v9(113.03,40.21) ; v12(108.09,41.87) 108.09,41.91 v9(107.88,42.12) ; v9(107.88,42.65) 107.98,42.76 v12(108.22,42.76)
  GND1 w0.254: v2(108.29,38.33) 108.06,38.33 v9(107.92,38.47) ; v9(111.53,39.85) 111.53,39.83 111.29,39.59 v2(111.27,39.59) ; v2(104.7,38.87) 104.77,38.87 v9(105.02,39.12) ; v2(108.29,38.94) v9(107.92,38.94) ; v2(102.43,37.52) 102.18,37.52 101.85,37.85 v9(101.85,37.88) ; v2(105,34.17) 104.59,34.17 v9(104.49,34.07)
  IN2 w0.254: v4(104.13,49.28) 102.96,50.45 100.91,50.45 99.69,51.67 v4(99.69,52.33)
  IN2 w0.381: v4(69.92,52.14) 69.46,52.59 69.46,54.59 69.21,54.85 67.56,54.85 67.13,54.41 67.13,53.58 66.01,52.46 61.11,52.46 58.72,54.85 58.72,55.33 55.01,59.04 44.95,59.04 43.81,57.89 v4(43.81,57.64)
  IN2 w1.016: v4(240.02,16.49) v4(239.13,16.49) 238.4,15.76 234.36,15.76 234.05,16.06 v4(231.51,16.06) v4(230.63,16.06) 228.14,16.06 228.06,16.14 222.14,16.14 221.23,15.22 219.83,15.22 219.37,15.68 215.72,15.68 215.34,16.06 203.75,16.06 200.4,19.41 196.72,19.41 193.03,15.73 189.86,15.73 188.5,14.37 186.14,14.37 186.05,14.46 181.55,14.46 181.35,14.66 172.64,14.66 171.57,15.73 169.84,15.73 168.78,14.66 v9(167.74,14.66) 164.36,14.66 163.77,15.25 162.22,15.25
  IN3 w0.254: v9(105.02,39.12) 104.44,39.71 104.44,40.6
  IN3 w0.381: v9(167.74,14.66) 167.56,14.49 167.56,11.51 v8(166.41,10.37) ; v4(45,43.57) 45.31,43.26 45.31,41.51 43,39.2 43,36.51 44.88,34.63 45.59,34.63 v4(46.68,33.54)
  IN3 w0.508: 94.43,39.56 94.51,39.48 v4(94.51,34.17)
  GND2 w0.127: v9(107.88,42.12) 107.88,41.95 v8(107.49,41.56) ; v9(107.88,42.65) 107.78,42.65 107.49,42.36 v8(107.49,42.22)
  GND2 w0.203: v9(113.03,40.21) v9(113.03,40.64) 113,40.67 112.72,40.67 v8(112.67,40.62) ; v8(110.77,43.52) 110.89,43.52 v9(111.17,43.23)
  GND2 w0.254: v8(111.4,39.22) 111.4,39.7 111.53,39.83 v9(111.53,39.85) ; v9(104.49,34.07) v7(104.49,33.66) ; v9(107.93,43.54) 108.34,43.95 v8(108.96,43.95)
  IN4 w0.203: v4(84.63,42) 84.59,41.97 84.59,34.19 86.65,32.14 86.65,29.53 87.52,28.66 89.2,28.66 ; v8(98.9,59.47) 98.54,59.83 70.44,59.83 69.44,58.83 69.44,52.62 v4(69.92,52.14)
  IN4 w0.381: v4(43.81,57.64) 43.81,57.39 44.24,56.95 44.24,51.49 45.97,49.77 45.97,44.53 v4(45,43.57)
  IN4 w1.016: 161.06,19.01 159.63,19.01 158.86,19.78 158.24,19.78 157.7,20.32 157.7,20.38 156.89,21.19 156.83,21.19 156.83,21.19 156.1,21.19 155.58,21.71 155.58,24.75 154.29,26.05 146.34,26.05 145.31,27.08 121.43,27.08 121.23,27.29 112.08,27.29 111.09,28.28 108.15,28.28 107.82,28.61
  BOTTOM w0.117: 54.1,22.17 v4(54.1,22.18)
  BOTTOM w0.203: v8(98.9,59.47) 98.9,58.86 99.69,58.07 v4(99.69,52.33) ; R505.1 85.42,24.33 85.44,24.31 88.33,24.31 88.94,24.92 88.94,27.59 89.05,27.69 89.63,27.69 89.88,27.95 89.88,28.4 89.81,28.48 ; R332.2 59.44,22.57 59.24,22.37 Q6072.5 Q6072.2 55.54,22.37 55.34,22.17 R337.2 54.1,22.17 ; C171.2 112.69,40.64 v8(112.67,40.62) ; R502.1 105.61,37.21 R205.1 106.17,37.21 106.45,36.93 106.45,36.66 106.78,36.33 107.14,36.33 107.35,36.12 107.35,35.98 107.61,35.72 108.45,35.72 ; Q6064.2 Q6064.5 55.37,30.08 54.39,31.06 54.39,31.22 54.05,31.57 52.22,31.57 51.4,30.75 48.06,30.75 46.68,32.14 v4(46.68,33.54) ; v8(108.96,43.95) R191.2 109.24,43.95 109.5,43.69 R192.2
  BOTTOM w0.381: R10957.2 165.17,9.63 165.44,9.9 Q6063.1
  vias: v4(85.06,42.48) v4(101.14,41.82) v4(102.71,44.41) v4(104.26,44.77) v4(108.05,38.62) v4(161.33,18.19) v4(161.97,18.19) v6(101.59,38.59) v6(101.59,38.34) v6(101.85,38.59) v6(101.85,38.34) v6(102.1,38.59) v6(102.1,38.34) v7(101.59,38.59) v7(101.59,38.34) v7(101.85,38.59) v7(101.85,38.34) v7(102.1,38.59) v7(102.1,38.34) v7(107.5,38.69) v7(107.49,37.88) v7(107.93,38) v8(89.43,28.66) v8(89.73,28.66) v8(107.5,38.69) v8(107.49,37.88) v8(107.93,38) v11(113.73,41.48) v11(113.73,40.92)
V7_V3.3A_PCH_PG: length 1.8
  GND1 w0.06: v2(71.57,42.63) 71.83,42.63 v9(71.98,42.48)
  GND2 w0.127: v8(72.46,42.3) 72.15,42.3 v9(71.98,42.48)
  BOTTOM w0.117: PR136.2 v8(72.46,42.3) 71.95,42.3 v4(71.83,42.43)
V8_V1.8A: length 53
  TOP w0.203: U3.AE16 v2(111.75,42.6)
  TOP w0.254: v2(108.29,39.6) 108.56,39.87 U3.AN2
  GND1 w0.203: v2(111.75,42.6) 111.27,42.6 110.84,42.17 v9(110.76,42.17)
  GND1 w0.254: v2(108.29,39.6) 107.93,39.6 v9(107.87,39.54)
  IN2 w0.508: 89.68,52.66 92.03,52.66 94.74,49.94 101.58,49.94 v4(102.18,49.34)
  IN3 w0.254: v9(107.87,39.54) 107.96,39.54 109.71,41.29 109.88,41.29 v9(110.76,42.17)
  GND2 w0.203: v8(107.43,39.47) 107.48,39.47 107.54,39.54 v9(107.87,39.54) ; v9(110.76,42.17) 110.76,42.15 110.13,41.51 v8(110.13,41.32)
  IN4 w0.254: v8(75.02,49.87) 75.02,49.74 74.29,49.01 74.29,47.51 74.89,46.91 74.89,36.08 v5(74.09,35.27)
  IN4 w0.508: v4(102.18,49.34) 102.07,49.23 102.04,49.23 101.7,48.89 101.7,43.48 102.29,42.9 108.01,42.9 109.07,41.84 109.65,41.84
  BOTTOM w0.117: C170.1 110.15,41.33 ; C170.1 110.33,41.34 110.33,41.33 110.3,41.33 ; C170.1 110.3,41.34 ; 110.15,41.33 110.29,41.34 ; 110.15,41.33 110.15,41.32 ; 110.15,41.33 110.15,41.32 ; 110.15,41.33 110.27,41.34 110.29,41.34 ; 110.15,41.33 110.15,41.32 ; 110.15,41.32 110.13,41.32 ; 110.15,41.32 110.15,41.32 ; 110.29,41.34 110.3,41.34 ; 110.15,41.32 110.18,41.32 ; 110.3,41.34 110.2,41.33 110.2,41.33
  BOTTOM w0.203: v8(75.02,49.87) 75,49.87 74.97,49.85 PR76.1
  vias: v4(73.58,34.58) v4(84.2,54.75) v4(84.83,54.73) v4(85.49,54.29) v5(73.35,35.27) v8(109.52,41.26) v8(109.85,41.26)
V8_V1.8A_PG: length 60.1
  TOP w0.064: 70.84,41.95 70.76,42.03 70.76,42.48 PU5.E12
  TOP w0.102: 70.84,41.95 v2(70.86,41.93)
  GND1 w0.102: v9(70.92,41.57) 70.84,41.65 70.84,41.9 v2(70.86,41.93)
  IN3 w0.094: v8(67.84,43.09) 67.94,43.19 68.98,43.19 70.6,41.57 v9(70.92,41.57)
  GND2 w0.127: v9(70.92,41.57) 70.92,41.8 v8(70.79,41.93)
  IN4 w0.071: v8(46.48,13.32) 46.77,13.32 47.84,12.25 48.08,12.25 49.01,13.18 51.56,13.18 51.88,12.87 53.46,12.87 53.85,12.48 54.98,12.48 55.73,13.23 55.73,15.77 55.96,16 55.96,20.87 58.01,22.92 58.01,23.37 63.21,28.57 63.65,28.57 64.54,29.45 65.33,29.45 67.99,32.11 67.99,32.77 68.73,33.51 68.73,38.15 70.22,39.65 v8(70.22,40.37)
  BOTTOM w0.117: R10959.2 46.35,13.19 v8(46.48,13.32) ; v8(67.84,43.09) 67.84,43.31 67.67,43.47 67.36,43.47 67.29,43.41 66.22,43.41 64.99,44.64 64.99,46.29 64.81,46.46 64.81,46.72 64.99,46.9 64.99,46.9 PR340.1 ; v8(70.22,40.37) 70.36,40.5 PR148.2 70.91,40.55 71.24,40.88 71.24,41.22 70.79,41.67 v8(70.79,41.93) 70.79,42.22 v4(70.53,42.48)
V8_V1.8A_PG_GPJ1: length 4
  BOTTOM w0.117: U17.D13 48.47,12.41 48.42,12.46 47.68,12.46 v4(46.93,13.22) 46.5,13.64 R10959.1 R10960.1
V10_V1.2U: length 26.7
  TOP w0.254: U3.BP64 U3.BN64
  TOP w0.508: PR29.2 78.79,47.68 v4(79.04,47.94)
  IN1 w0.381: v4(156.56,22.04) 156.56,21.29 153.28,18.01 v13(151.33,18.01)
  IN2 w0.508: v5(83.64,52.77) 83.64,51.93 82.47,50.76 81.87,50.76 v4(79.04,47.94)
  GND2 w0.203: v8(126.66,32.44) 126.66,32.93 v9(126.64,32.95) ; v9(115.28,34.12) 115.31,34.09 v8(115.31,33.1) ; v9(127.22,33.91) 127.27,33.87 v8(127.86,33.87)
  GND2 w0.254: v9(117.62,32.93) 117.42,32.72 v8(117.42,32.49) ; v8(120.87,33.42) 120.66,33.64 v9(120.14,33.64) 120.03,33.54 v8(120.03,33.1) ; v8(118.28,33.73) 117.94,33.73 v9(117.62,33.41)
  BOTTOM w0.203: R258.2 109.04,27.22 ; R306.2 v4(156.56,22.04) ; 136.9,34.88 136.9,36.61 138.13,37.84 R200.2
  vias: v1(115.67,37.54) v1(116.31,37.61) v1(116.98,37.56) v1(117.59,37.56) v1(118.24,37.56) v1(118.89,37.54) v1(120.18,37.54) v1(120.82,37.54) v1(121.46,37.54) v1(122.11,37.54) v1(122.75,37.54) v1(123.4,37.54) v2(115.67,37.54) v2(116.31,37.61) v2(116.98,37.56) v2(120.18,37.54) v2(120.82,37.54) v2(121.46,37.54) v2(122.11,37.54) v2(122.75,37.54) v2(123.4,37.54) v4(81.55,53.75) v4(100.65,29.88) v4(100.65,29.24) v4(101.29,29.88) v4(101.29,29.24) v4(101.95,29.88) v4(101.95,29.24) v4(102.58,29.88) v4(107.91,13.95) v4(125.66,14.09) v4(126.31,14.92) v4(136.52,16.16) v4(138.17,14.87) v4(153.31,39.45) v4(153.89,38.74) v5(81.38,52.77) v5(82.11,52.77) v5(82.85,52.77) v5(84.37,52.77) v5(85.11,52.77) v7(120.14,36.94) v7(120.42,36.94) v7(120.69,36.94) v7(120.95,36.94) v7(121.2,36.94) v7(122.65,33.18) v7(123.46,33.18) v8(120.14,36.94) v8(120.42,36.94) v8(120.69,36.94) v8(120.95,36.94) v8(121.2,36.94) v8(122.65,33.18) v8(123.46,33.18) v9(116,37.49) v9(116.64,37.49) v9(119.86,37.32) v9(120.49,37.37) v9(121.14,37.39) v9(121.79,37.39) v9(122.43,37.39) v9(122.75,33.97) v9(123.07,37.39) v9(123.06,33.66) v10(120.14,36.94) v10(120.42,36.94) v10(120.69,36.94) v10(120.95,36.94) v10(121.2,36.94) v11(115.02,37.54) v11(115.29,33.28) v11(115.29,33.03) v11(117.6,34.04) v11(117.6,33.76) v11(117.6,32.54) v11(117.6,32.24) v11(120.13,33.28) v11(120.13,33.03) v11(122.78,33.46) v11(122.78,33.21) v11(126.23,33.23) v11(126.55,33.91) v11(126.48,33.23) v11(126.8,33.91) v12(115.29,33.28) v12(115.29,33.03) v12(117.6,34.04) v12(117.6,33.76) v12(117.6,32.54) v12(117.6,32.24) v12(120.13,33.28) v12(120.13,33.03) v12(122.78,33.46) v12(122.78,33.21) v12(126.23,33.23) v12(126.55,33.91) v12(126.48,33.23) v12(126.8,33.91) v13(100.7,19.74) v13(100.7,18.95) v13(102.37,23.5) v13(102.7,17.35) v13(102.7,16.56) v13(102.7,15.75) v13(103.4,22.9) v13(103.38,19.71) v13(104,14.16) v13(104.65,16.56) v13(104.72,14.11) v13(105.25,22.88) v13(105.3,17.35) v13(106.64,21.3) v13(106.57,20.48) v13(107.33,22.9) v13(109.21,19.68) v13(109.84,17.36) v13(109.82,16.54) v13(111.71,19.69) v13(111.85,22.12) v13(119.22,19.72) v13(120.47,17.35) v13(120.47,15.75) v13(122.42,14.15) v13(123.07,17.35) v13(123.71,18.86) v13(124.32,21.29) v13(124.34,20.48) v13(124.36,17.36) v13(125.04,22.94) v13(125.03,17.3) v13(124.96,16.51) v13(125.1,19.7) v13(125.59,16.48) v13(126.49,22.94) v13(126.98,19.68) v13(127.61,17.36) v13(127.59,16.54) v13(127.61,15.76) v13(128.14,22.95) v13(129.64,21.99) v13(129.57,18.86) v13(142.56,23.74) v13(142.64,19.3) v13(142.59,15.41) v13(144.22,19.29) v13(144.99,36.71) v13(144.98,19.31) v13(145.01,14.13) v13(145.75,14.13) v13(145.8,39.89) v13(145.82,35.97) v13(145.79,21.93) v13(145.82,18.64) v13(148.13,37.93) v13(148.14,36.64) v13(148.14,35.99) v13(148.14,19.31) v13(148.14,18.66) v13(148.14,16.06) v13(148.18,40.59) v13(148.15,34.02) v13(148.18,23.26) v13(148.93,38.58) v13(148.95,36.62) v13(148.93,35.34) v13(148.93,21.25) v13(148.93,18.66) v13(148.93,16.06) v13(148.96,40.58) v13(148.96,23.25) v13(149.74,16.06) v13(149.78,40.59) v13(149.83,37.9) v13(149.81,20.61) v13(150.57,38.59) v13(150.59,21.21)
V10_V1.2U_AE27: length 14.3
  IN3 w0.305: v9(115.36,42.98) 115.46,43.09 115.46,45.6 114.55,46.51 114.55,46.83 114.18,47.2 114.1,47.2 112.91,48.39 112.91,49.31
  IN3 w0.508: 112.91,49.31 112.91,49.71 114.04,50.83 114.04,53.37 112.67,54.74
  GND2 w0.254: v9(115.36,42.98) 115.24,42.86 v8(115.03,42.86)
  vias: v1(115.72,42.6) v1(115.72,42.22) v2(115.72,42.6) v2(115.72,42.22) v4(111.65,54.85) v7(112.29,56.11) v7(112.29,55.84) v7(112.26,55.48) v8(112.29,56.11) v8(112.29,55.84) v8(112.26,55.48) v10(112.29,56.11) v10(112.29,55.84) v10(112.26,55.48)
V10_V1.2U_PG: length 20
  TOP w0.102: 68.22,41.72 68.52,42.02 PU5.J13
  TOP w0.117: v2(67.4,41.26) 67.76,41.26 68.22,41.72
  GND1 w0.127: v9(67.15,41.04) 67.18,41.04 v2(67.4,41.26)
  IN3 w0.094: v9(67.15,41.04) 67.15,41.1 67.81,41.76 68.19,41.76 68.7,41.26 69.46,41.26 69.71,41.01 71.09,41.01 72.46,42.38 73.3,42.38 73.58,42.66 73.58,43.68 73.02,44.24 73.02,45.63 72.57,46.07 72.57,46.5 72.82,46.74 73.29,46.74 v8(74.72,48.17)
  GND2 w0.127: v9(67.15,41.04) 67.43,40.76 v8(67.43,40.76)
  BOTTOM w0.117: v8(74.72,48.17) 74.72,47.94 75.25,47.41 v4(75.25,46.72) ; PR151.2 66.72,40.45 67.02,40.76 v8(67.43,40.76)
V11_V1.00A: length 40
  TOP w0.203: U3.AH13 111.31,41.48 U3.AH15
  IN1 w0.203: v3(123.29,52.21) 123.59,52.51 123.97,52.51 125.59,54.13 128.81,54.13 v1(129.31,53.63)
  GND1 w0.127: v9(112.18,45.4) 112.18,45.4 v2(111.75,45.4)
  GND1 w0.203: v9(112.74,44.4) v2(112.74,44.84) ; v2(113.71,43.72) v9(114.06,43.72) ; v2(108.29,45.44) 107.94,45.44 v9(107.89,45.39) ; v9(113.86,39.48) 113.73,39.35 v2(113.73,38.69) ; v2(111.25,41.52) 111.47,41.52 v9(111.58,41.63) ; v2(108.29,44.75) v9(107.91,44.75)
  GND1 w0.254: v2(113.24,44.84) v9(113.24,44.38) ; v2(113.73,45.95) 113.98,45.95 v9(114.08,45.85)
  IN2 w0.203: v9(122.3,51.6) 122.47,51.78 122.85,51.78 v3(123.29,52.21)
  GND2 w0.203: v8(121.64,51.68) 122.22,51.68 v9(122.3,51.6) ; v8(111.73,41.18) 111.73,41.48 v9(111.58,41.63) ; v9(107.89,45.39) 107.59,45.7 107.59,45.76 v8(107.33,46.01) ; v9(107.91,44.75) 107.88,44.75 107.41,45.22 v8(107.41,45.3)
  GND2 w0.254: v8(111.58,42.09) v9(111.58,41.63)
  BOTTOM w0.203: v8(114.15,44.61) C478.1 ; v8(121.64,51.68) 122.27,51.04 122.27,50.65 121.95,50.34 121.11,50.34 120.14,49.36 120.14,48.83 119.82,48.51 114.28,48.51 ; C103.2 C479.1 ; 60.7,32.85 60.74,32.89 64.01,32.89 64.46,33.33 64.46,35.06 64.28,35.24 64.28,36.86 64.08,37.07 64.08,39.89 v4(64.29,40.1) PR147.1
  vias: v1(111.75,45.95) v1(111.75,44.84) v1(111.75,43.72) v1(112.25,44.84) v1(112.24,43.72) v1(112.74,41.48) v1(113.24,45.95) v1(113.24,41.48) v1(113.73,44.84) v1(113.71,44.28) v1(114.21,44.83) v1(114.17,44.25) v1(114.24,40.98) v1(114.22,40.34) v1(114.24,39.81) v1(114.23,39.3) v2(111.75,45.95) v2(111.75,44.84) v2(112.25,44.84) v2(112.24,43.72) v2(112.74,41.48) v2(113.24,41.48) v2(113.71,44.28) v2(114.17,44.25) v2(114.24,40.98) v2(114.22,40.34) v2(114.24,39.81) v2(114.23,39.3) v3(112.24,43.72) v3(113.71,44.28) v3(114.17,44.25) v3(114.24,40.98) v3(114.22,40.34) v3(114.24,39.81) v3(114.23,39.3) v4(89.78,46.68) v4(90.42,46.7) v4(91.05,46.7) v4(103.04,42.83) v4(110.92,59.21) v4(110.94,52.23) v5(59.89,34.68) v5(59.89,33.94) v5(60.32,35.31) v5(60.73,34.68) v5(60.73,33.94) v5(76.71,34.01) v5(77.13,33.4) v5(77.48,34.05) v5(78.24,34.05) v7(109.65,47.84) v7(110.79,46.26) v7(110.81,45.42) v7(111.14,44.89) v7(111.17,44.64) v7(113.25,43.85) v7(113.53,45.6) v7(114.14,41.28) v7(114.12,40.47) v7(114.15,39.76) v8(102.91,43.97) v8(102.91,43.64) v8(103.27,43.97) v8(103.27,43.64) v8(103.6,43.97) v8(103.6,43.64) v8(109.65,47.84) v8(110.79,46.26) v8(110.81,45.42) v8(110.76,44.36) v8(111.14,44.89) v8(111.09,44.36) v8(111.17,44.64) v8(111.53,48.34) v8(111.53,48.04) v8(111.53,47.73) v8(111.83,48.34) v8(111.86,48.01) v8(111.86,47.73) v8(112.04,46.36) v8(113.25,43.85) v8(113.53,45.6) v8(114.14,41.28) v8(114.12,40.47) v8(114.15,39.76) v9(111.12,45.73) v9(111.55,44.46) v9(111.96,44.56) v9(112.08,45.83) v9(112.97,41.23) v9(113.9,40.74) v10(109.65,47.84)
V11_V1.00A_PG: length 63
  TOP w0.064: PU5.M9 v2(66.78,43.98)
  GND1 w0.102: v2(66.78,43.98) 66.39,43.98 66.34,44.04 v9(66.34,44.08)
  IN3 w0.094: v7(43.76,15.7) 43.76,11.34 45.71,9.38 46.65,9.38 49.14,6.89 49.14,4.88 49.63,4.4 v4(49.63,3.82)
  GND2 w0.127: v9(66.34,44.08) 66.77,43.65 v8(67,43.65)
  IN4 w0.071: v8(67,43.65) 67.23,43.42 67.23,43.13 67.42,42.94 67.42,41.15 67.7,40.87 67.7,40.41 67.36,40.07 67.36,34.08 66.46,33.17 66.46,32.49 65.1,31.13 64.01,31.13 63.44,30.57 62.43,30.57 59.91,28.05 59.46,28.05 56.53,25.13 56.1,25.13 55.44,24.46 55.44,22.9 53.74,21.2 53.74,19.16 52.5,17.91 52.5,16.62 51.82,15.94 48.45,15.94 48.1,16.29 47.7,16.29 47.19,15.78 46.12,15.78 45.97,15.93 44.34,15.93 44.11,15.7 v7(43.76,15.7)
  BOTTOM w0.117: R10948.2 49.9,4.1 v4(49.63,3.82) v4(49.63,3.18)
V12_V0.85A: length 36.2
  GND2 w0.203: v9(112.31,39.35) 112.31,39.58 v8(112.66,39.94)
  IN4 w1.524: 111.68,34.98 111.68,31.12 113.02,29.78 142.69,29.78
  vias: v1(112.25,39.02) v1(112.25,38.69) v1(112.74,42.6) v1(112.8,42.22) v1(113.24,42.6) v1(113.25,42.22) v2(112.25,39.02) v2(112.25,38.69) v2(112.74,42.6) v2(112.8,42.22) v2(113.24,42.6) v2(113.25,42.22) v4(113.53,42.02) v4(158.36,33.56) v4(158.69,34.12) v4(159,33.56) v7(111.2,36.14) v7(111.62,36.13) v7(112.03,36.14) v7(112.43,36.15) v7(112.71,42.63) v7(112.95,36.17) v7(113.07,42.25) v8(112.71,42.63) v8(113.07,42.25) v8(158.52,32.98) v8(158.74,32.62) v8(158.95,32.95) v9(112.77,41.89) v9(113.33,41.89) v10(111.2,36.14) v10(111.62,36.13) v10(112.03,36.14) v10(112.43,36.15) v10(112.95,36.17)
V12_V0.85A_PG: length 20
  IN1 w0.203: v1(75.53,50.63) 75.97,50.2 75.97,49.18 72.92,46.13 72.92,45.14 72.54,44.76 72.08,44.76 70.89,43.57 70.25,43.57 70.05,43.37 70.05,41.18 69.74,40.88 v2(69.74,40.44)
  GND1 w0.203: v9(70.22,40.44) v2(69.74,40.44)
  GND2 w0.203: v9(70.22,40.44) 70.22,40.47 70,40.7 70,40.77 69.8,40.98 v8(69.59,40.98)
  BOTTOM w0.203: PR143.2 66.71,41.27 66.8,41.18 67.1,41.18 67.39,41.47 v4(67.39,41.9) 67.39,42.06 67.71,42.37 68.07,42.37 68.24,42.2 68.24,41.94 68.48,41.71 68.85,41.71 v8(69.59,40.98)
V12_V0.85A_PG_IC: length 132
  TOP w0.203: v3(103.98,11.49) 102.3,11.49 99.54,14.25 99.54,21.1 96.25,24.39 96.25,25.85 95.52,26.58 94.97,26.58 92.81,24.42 90.37,24.42 85.85,28.94 82.81,28.94 81.66,30.08 73.49,30.08 72.4,31.17 67.91,31.17 66.17,32.91 v4(66.17,33.94) PR54.1
  IN2 w0.203: v3(103.98,11.49) 104.5,10.98 124.91,10.98 127.5,13.57 132.07,13.57 132.86,12.79 151.85,12.79 152.08,13.02 156.69,13.02 157.09,13.43 157.09,14.89 158.44,16.24 158.44,17.66 160.78,20 166.21,20 167.2,20.99 167.2,21.5 165.78,22.92 163.92,22.92 v4(163.38,23.47)
  BOTTOM w0.203: PR233.1 163.71,24.02 163.68,24.05 PR231.2 163.26,23.58 v4(163.38,23.47)
VCCCOREG0: length 0.7
  GND1 w0.254: v9(118.34,42.88) 118.15,43.06 v2(118.15,43.19) ; v2(119.17,43.16) 119.17,43.05 v9(119.34,42.88)
  vias: v1(118.18,45.98) v1(118.15,45.37) v1(118.15,44.84) v1(118.15,44.25) v1(118.18,43.72) v1(119.14,45.96) v1(119.17,45.37) v1(119.17,44.86) v1(119.17,44.25) v1(119.18,43.72) v2(118.18,45.98) v2(118.15,45.37) v2(118.15,44.84) v2(118.15,44.25) v2(119.14,45.96) v2(119.17,45.37) v2(119.17,44.86) v2(119.17,44.25) v7(118.65,45.51) v7(118.66,44.41) v7(118.68,42.89) v7(119.05,45.4) v7(119,44.62) v7(119.07,44.89) v7(119.11,44.1) v7(119.09,43.46) v8(118.65,45.51) v8(118.66,44.41) v8(118.68,42.89) v8(119.05,45.4) v8(119,44.62) v8(119.07,44.89) v8(119.11,44.1) v8(119.09,43.46) v9(118.34,45.68) v9(118.34,44.56) v9(119.33,45.68) v9(119.33,44.56)
VCCCOREG1: length 0.4
  TOP w0.06: U3.AR35 v3(118.1,39.28)
  IN2 w0.203: v9(118.35,41.82) 118.35,41.84 118.13,42.06 v3(118.13,42.07)
  vias: v1(118.13,41.49) v1(118.13,40.37) v1(118.19,40.92) v1(118.15,39.78) v1(119.14,39.22) v1(119.17,42.07) v1(119.17,41.46) v1(119.17,40.93) v1(119.17,40.37) v1(119.17,39.83) v2(118.15,39.78) v2(119.14,39.22) v2(119.17,42.07) v2(119.17,41.46) v2(119.17,40.93) v2(119.17,40.37) v2(119.17,39.83) v3(118.15,39.78) v7(118.56,41.51) v7(118.59,41) v7(118.64,40.37) v7(118.66,39.77) v7(119.11,41.49) v7(119.14,40.93) v7(119.13,40.36) v7(119.14,39.81) v8(118.56,41.51) v8(118.59,41) v8(118.64,40.37) v8(118.66,39.77) v8(119.11,41.49) v8(119.14,40.93) v8(119.13,40.36) v8(119.14,39.81) v9(118.35,39.5) v9(119.33,41.77) v9(119.34,39.53)
VCCGT: length 10.9
  TOP w0.06: U3.AF49 122.65,42.02
  GND1 w0.127: v3(121.67,39.78) 121.63,39.78 v9(121.41,40) ; v3(122.65,43.11) 122.64,43.11 v9(122.4,43.36) 122.17,43.12 v3(122.15,43.12) ; v3(121.64,44.23) 121.64,44.25 v9(121.41,44.47) ; v9(121.41,42.24) 121.66,41.99 v3(121.68,41.99) ; v3(123.65,42.01) 123.64,42.01 v9(123.4,42.24) ; v3(123.66,40.92) 123.63,40.92 v9(123.4,41.14) 123.16,40.89 v3(123.16,40.86) ; v3(123.16,44.22) 123.16,44.25 v9(123.39,44.48) 123.61,44.26 v3(123.66,44.26) ; v3(121.65,45.35) 121.42,45.58 v9(121.41,45.58) ; v3(122.63,40.88) 122.63,40.89 v9(122.4,41.12) 122.17,40.89 v3(122.17,40.88) ; v3(123.15,39.79) 123.17,39.79 v9(123.39,40.01) 123.59,39.81 v3(123.66,39.81) ; v3(120.67,44.26) 120.67,44.28 v9(120.9,44.51) ; v9(121.41,43.36) 121.65,43.12 v3(121.67,43.12) ; v3(122.17,44.23) 122.17,44.24 v9(122.4,44.47) 122.64,44.24 v3(122.65,44.24) ; v3(121.66,40.87) 121.66,40.87 v9(121.41,41.12) ; v3(123.14,45.37) 123.14,45.39 v9(123.39,45.64) v3(123.64,45.4) ; v3(122.17,45.34) 122.17,45.35 v9(122.4,45.59) 122.61,45.38 v3(122.61,45.33) ; v3(123.66,43.15) 123.6,43.15 v9(123.39,43.36) 123.15,43.12 v3(123.14,43.12) ; v3(120.68,43.12) 120.68,43.17 v9(120.9,43.39) ; v3(120.67,39.8) 120.67,39.8 v9(120.9,40.03) ; v3(120.69,40.89) 120.69,40.94 v9(120.9,41.15) ; v3(123.66,38.69) 123.59,38.69 v9(123.39,38.89) 123.17,38.67 v3(123.13,38.67)
  vias: v1(120.71,45.37) v1(120.67,42.02) v1(120.67,38.69) v1(121.14,45.36) v1(121.14,44.24) v1(121.14,43.13) v1(121.14,41.99) v1(121.15,40.9) v1(121.14,39.78) v1(121.18,38.69) v1(121.63,38.68) v1(121.78,46.4) v1(122.14,42.01) v1(122.14,38.66) v1(122.17,39.8) v1(122.43,46.41) v1(122.61,39.78) v1(122.65,38.66) v1(122.66,42.01) v1(123.07,46.41) v1(123.13,42.01) v1(124.18,44.43) v1(124.17,43.13) v1(124.65,43.12) v1(124.66,44.42) v1(125.16,44.42) v1(125.16,43.12) v1(125.65,44.42) v1(125.65,43.11) v1(126.15,43.1) v1(126.16,44.42) v1(126.64,43.11) v1(126.66,44.41) v2(120.71,45.37) v2(120.67,42.02) v2(120.67,38.69) v2(121.14,45.36) v2(121.14,44.24) v2(121.14,43.13) v2(121.14,41.99) v2(121.15,40.9) v2(121.14,39.78) v2(121.18,38.69) v2(121.63,38.68) v2(121.78,46.4) v2(122.14,42.01) v2(122.14,38.66) v2(122.17,39.8) v2(122.43,46.41) v2(122.61,39.78) v2(122.65,38.66) v2(122.66,42.01) v2(123.07,46.41) v2(123.13,42.01) v2(124.18,44.43) v2(124.17,43.13) v2(124.65,43.12) v2(124.66,44.42) v2(125.16,44.42) v2(125.16,43.12) v2(125.65,44.42) v2(125.65,43.11) v2(126.15,43.1) v2(126.16,44.42) v2(126.64,43.11) v2(126.66,44.41) v3(120.71,45.37) v3(120.67,42.02) v3(120.67,38.69) v3(121.14,45.36) v3(121.14,44.24) v3(121.14,43.13) v3(121.14,41.99) v3(121.15,40.9) v3(121.14,39.78) v3(121.18,38.69) v3(121.63,38.68) v3(121.78,46.4) v3(122.14,42.01) v3(122.14,38.66) v3(122.17,39.8) v3(122.43,46.41) v3(122.61,39.78) v3(122.65,38.66) v3(122.66,42.01) v3(123.07,46.41) v3(123.13,42.01) v3(124.18,44.43) v3(124.17,43.13) v3(124.65,43.12) v3(124.66,44.42) v3(125.16,44.42) v3(125.16,43.12) v3(125.65,44.42) v3(125.65,43.11) v3(126.15,43.1) v3(126.16,44.42) v3(126.64,43.11) v3(126.66,44.41) v4(127.35,43.75) v4(128.14,43.73) v4(128.42,40.72) v4(141.37,47) v4(157.5,47.07) v4(165.6,47) v5(131.03,46.13) v5(131.85,46.11) v5(132.05,46.84) v5(132.61,46.11) v5(132.81,46.84) v5(133.37,46.08) v5(133.57,46.82) v5(134.16,46.06) v5(134.36,46.79) v5(134.89,46.06) v5(135.1,46.79) v5(135.63,46.06) v5(135.83,46.79) v5(136.37,46.06) v5(136.57,46.79) v5(165.15,44.41) v5(165.15,43.68) v5(165.15,42.94) v5(165.17,45.2) v5(165.91,45.2) v5(165.88,44.41) v5(165.88,43.68) v5(165.88,42.94) v5(166.64,45.2) v5(166.62,44.41) v5(166.62,43.68) v5(166.62,42.94) v5(167.33,42.13) v5(167.38,45.2) v5(167.36,44.41) v5(167.36,43.68) v5(167.36,42.94) v5(168.12,45.2) v5(168.09,44.41) v5(168.09,43.68) v5(168.09,42.94) v5(168.12,42.15) v5(168.93,45.23) v5(168.93,44.49) v7(121.11,45.34) v7(121.14,44.25) v7(121.13,43.13) v7(121.14,41.97) v7(121.12,40.86) v7(121.14,39.79) v7(121.16,38.64) v7(121.66,45.34) v7(121.66,44.25) v7(121.66,43.1) v7(121.66,41.99) v7(121.66,40.87) v7(121.67,39.8) v7(121.66,38.64) v7(122.15,45.34) v7(122.15,41.98) v7(122.15,38.66) v7(122.16,44.23) v7(122.17,43.1) v7(122.16,40.8) v7(122.15,39.79) v7(122.65,45.34) v7(122.65,44.24) v7(122.55,40.8) v7(122.58,39.76) v7(122.66,43.09) v7(122.66,41.98) v7(123.14,44.18) v7(123.15,43.1) v7(123.15,41.98) v7(123.1,40.78) v7(123.15,39.78) v7(123.15,45.33) v7(123.44,40.78) v7(123.75,45.65) v7(123.72,44.3) v7(123.71,43.12) v7(123.68,41.98) v7(123.65,39.79) v8(121.11,45.34) v8(121.14,44.25) v8(121.13,43.13) v8(121.14,41.97) v8(121.12,40.86) v8(121.14,39.79) v8(121.16,38.64) v8(121.66,45.34) v8(121.66,44.25) v8(121.66,43.1) v8(121.66,41.99) v8(121.66,40.87) v8(121.67,39.8) v8(121.66,38.64) v8(122.15,38.66) v8(122.65,45.34) v8(122.65,44.24) v8(122.55,40.8) v8(122.66,43.09) v8(122.66,41.98) v8(123.44,40.78) v8(123.75,45.65) v8(123.72,44.3) v8(123.71,43.12) v8(123.68,41.98) v8(127.32,44.28) v8(128.14,44.28) v8(128.85,44.28) v9(120.91,45.64) v9(120.9,42.27) v9(120.93,38.91) v9(121.41,38.94) v9(122.4,42.24) v9(122.4,40.07) v9(122.4,38.88) v9(124.05,45.37) v9(124.43,44.69) v9(124.38,44.07) v9(124.93,44.69) v9(124.91,43.35) v9(124.89,42.82) v9(125.44,44.69) v9(125.4,44.12) v9(125.41,43.35) v9(125.38,42.85) v9(125.88,44.12) v9(125.9,43.35) v9(125.87,42.83) v9(126.38,44.18) v9(126.4,43.35) v9(126.94,44.2) v11(124.17,42.49) v11(124.67,42.49) v11(125.16,42.49) v11(125.65,42.49) v11(126.15,42.49) v11(126.68,42.52)
VCCGT_SENSE: length 80
  IN2 w0.254: v4(166.1,21.98) 166.1,21.23 165.71,20.84 161.94,20.84 159.2,23.58 157.95,23.58 155.66,25.87 155.66,42.61 154.14,44.13 147.89,44.13 145.31,46.72 139.63,46.72 138.25,48.1 127.28,48.1 126.21,47.03 125.45,47.03 125.13,46.72 v9(125.09,46.72) 124.85,46.48 123.79,46.48 v3(123.72,46.41)
  GND2 w0.254: v8(125.6,45.4) 125.6,46.16 125.09,46.67 v9(125.09,46.72)
  BOTTOM w0.203: PR285.1 174.73,17.16 173.79,16.23 172.53,16.23 172.14,15.83 170.76,15.83 166.1,20.49 v4(166.1,21.98) ; v8(125.6,45.4) PR122.2
VCCIO_C0: length 3.5
  TOP w0.203: PR30.1 52.04,43.87 52.22,43.69 v4(52.22,43.54) 52.22,43.26 52.66,42.82 PU7.4
  BOTTOM w0.203: PR30.1 51.89,43.87 v4(52.22,43.54) v4(52.95,43.54)
VCCIO_C1: length 3.3
  TOP w0.203: PR22.2 PR26.1 51.93,45.14 v4(52.39,44.69) 52.39,44.36 53.06,43.69 PU7.3
VCCIO_ENA: length 29.1
  IN3 w0.203: v8(69.95,48.76) 69.88,48.69 69.26,48.69 68.27,49.69 68,49.69 67.92,49.77 64.51,49.77 63,51.27 60.3,51.27 58.43,49.4 58.43,45.26 59.13,44.56 59.13,44 58.49,43.37 54.93,43.37 53.56,41.99 v4(50.62,41.99)
  BOTTOM w0.203: v4(50.62,41.99) 50.92,41.99 PR135.2
VCCIO_LP#: length 4.8
  TOP w0.117: PR40.2 51.65,41.23 51.56,41.13 49.93,41.13 v4(49.57,40.77)
  TOP w0.203: PU7.6 52.32,41.82 52.01,41.51 PR40.2 PR39.2
VCCPLL_OC: length 33.2
  IN4 w0.508: v8(89.02,59.32) v8(89.73,59.32) v4(90.37,59.32) 97.42,59.32 98.19,58.55 99.41,58.55 100.33,59.48 106.51,59.48 106.93,59.06 107.63,59.06 107.86,58.83 110.76,58.83 111.09,59.16 v8(112.31,59.16) v8(112.31,58.66)
  BOTTOM w0.508: PC239.2 v4(85.85,59.4) 85.92,59.33 89.02,59.33 v8(89.02,59.32) 89.02,59.33 89.05,59.33 89.05,59.32 v8(89.73,59.32) v4(90.37,59.32) ; R146.2 112.29,57.31 112.41,57.44 112.41,57.74 112.31,57.84 v8(112.31,58.66) v8(112.31,59.16)
VCCPLL_OC_S2:
  vias: v4(81.45,59.21) v4(81.48,58.56) v4(82.16,58.56)
VCCPRTCEXT: length 1.1
  GND1 w0.127: v9(112.85,38.58) 112.77,38.5 v2(112.77,38.25)
  GND2 w0.127: v9(112.85,38.58) 112.17,38.58 v8(112.14,38.55)
VCCSA: length 2.7
  BOTTOM w0.203: 116.83,51.67 117.06,51.44 117.06,49.56 117.29,49.34 PR79.1
  vias: v1(116.15,45.4) v1(116.15,44.84) v1(116.15,44.28) v1(116.15,43.72) v1(116.15,43.16) v1(116.15,41.49) v1(116.15,40.93) v1(116.15,40.37) v1(116.15,39.81) v1(116.2,45.98) v1(116.22,42.55) v1(116.2,42.12) v1(116.2,39.22) v1(116.59,44.28) v1(116.59,43.16) v1(116.59,42.07) v1(116.59,40.95) v1(116.59,39.81) v2(116.15,45.4) v2(116.15,44.84) v2(116.15,44.28) v2(116.15,43.72) v2(116.15,43.16) v2(116.15,41.49) v2(116.15,40.93) v2(116.15,40.37) v2(116.15,39.81) v2(116.2,45.98) v2(116.22,42.55) v2(116.2,42.12) v2(116.59,44.28) v2(116.59,43.16) v2(116.59,42.07) v2(116.59,40.95) v2(116.59,39.81) v3(116.15,45.4) v3(116.15,44.84) v3(116.15,44.28) v3(116.15,43.72) v3(116.15,43.16) v3(116.15,41.49) v3(116.15,40.93) v3(116.15,40.37) v3(116.15,39.81) v3(116.2,45.98) v3(116.22,42.55) v3(116.2,42.12) v3(116.59,44.28) v3(116.59,42.07) v3(116.59,40.95) v3(116.59,39.81) v4(117.01,54.97) v4(129.25,56.65) v4(149.9,49.18) v4(150.74,55.35) v4(150.87,56.27) v5(115.64,53.32) v5(115.64,52.59) v5(116.28,53.7) v5(116.3,52.97) v5(116.3,52.23) v5(116.33,51.49) v5(117.04,52.97) v5(117.09,52.23) v5(138.37,55.23) v5(139.29,55.26) v5(140.15,55.24) v5(141.06,55.26) v5(151.58,55.41) v5(151.58,54.68) v5(151.58,53.94) v5(151.58,53.2) v7(116.56,45.39) v7(116.58,43.72) v7(116.58,43.18) v7(116.56,41.49) v7(116.63,40.95) v7(116.56,40.36) v8(116.56,45.39) v8(116.58,43.72) v8(116.58,43.18) v8(116.56,41.49) v8(116.63,40.95) v9(116.37,45.68) v9(116.37,45.11) v9(116.37,44.56) v9(116.37,44) v9(116.37,43.44) v9(116.37,42.89) v9(116.39,41.79) v9(116.37,41.21) v9(116.38,40.65) v9(116.37,40.08) v10(116.56,45.39) v10(116.58,43.72) v10(116.58,43.18) v10(116.56,41.49) v10(116.63,40.95) v10(116.56,40.36) v11(116.63,46.9) v11(116.63,46.41) v11(116.58,45.4)
VCCSA_DDR: length 11.7
  IN2 w0.254: v9(115.31,48.88) 115.31,47.73 115.49,47.56 115.49,46.92 115.94,46.46 116.45,46.46 116.84,46.07 116.84,44.56 116.92,44.48 116.92,44.15 116.83,44.06 116.83,42.32 116.91,42.24 116.91,41.93 116.87,41.89 116.87,41.14 116.92,41.09 116.92,40.79 116.87,40.74 116.87,39.99 116.92,39.94 116.92,39.68 116.65,39.41 116.54,39.41 v9(116.15,39.02)
  GND2 w0.203: v8(116.47,38.95) 116.22,38.95 v9(116.15,39.02)
  vias: v1(116.22,38.69) v1(116.71,38.69) v2(116.22,38.69) v2(116.71,38.69) v4(115.18,50.27) v7(114.93,49.51) v7(114.93,49.21) v7(114.93,48.9) v8(114.93,49.51) v8(114.93,49.21) v8(114.93,48.9) v10(114.93,49.51) v10(114.93,49.21) v10(114.93,48.9)
VCCSA_SENSE: length 131.1
  GND1 w0.254: v2(116.31,46.65) 116.53,46.44 117.03,46.44 v9(117.06,46.47)
  IN3 w0.254: v9(117.06,46.47) 116.71,46.83 116.71,47.58 117.34,48.21 117.34,49.61 v8(117.52,49.79) 117.85,49.79 125.94,57.89 158.3,57.89 166.21,49.97 175.44,49.97 176.57,51.1 185.02,51.1 186.31,49.81 186.9,49.81 187.54,49.17 190.01,49.17 192.34,46.84 192.34,33.79 186.58,28.02 184.98,28.02 183.74,26.78 183.74,21.22 180.39,17.87 177.67,17.87 176.64,16.84 176.64,16.36 176.34,16.06 v4(175.53,16.06)
  BOTTOM w0.117: v4(175.53,16.06) 175.43,15.96 174.57,15.96 v4(174.49,16.03)
  BOTTOM w0.203: v4(175.53,16.06) 175.62,15.97 PR301.1
VCCSENSE: length 105
  GND1 w0.254: v9(117.65,46.71) 117.76,46.71 v2(117.95,46.9)
  IN3 w0.254: v9(117.65,46.71) 118.08,47.14 118.08,48.85 119.02,49.79 v8(119.2,49.79) 119.55,49.79 120.3,50.54 120.3,51.33 120.97,52.01 120.97,52.01 126.21,57.25 158.03,57.25 165.95,49.33 185.67,49.33 185.83,49.17 186.63,49.17 187.28,48.53 188.77,48.53 191.59,45.71 191.59,33.95 187.42,29.78 v4(186.53,29.78)
  BOTTOM w0.203: PR192.1 186.08,28.84 186.53,29.29 v4(186.53,29.78)
VCCST_PWRGD: length 73.1
  GND1 w0.14: v2(70.44,46.73) v9(70.69,46.97)
  GND2 w0.117: v8(70.46,47.34) 70.69,47.11 v9(70.69,46.97)
  IN4 w0.071: v8(118.66,53.81) 118.66,53.87 115.38,57.15 113.84,57.15 113.69,57 104.84,57 104.13,57.72 97.1,57.72 96.26,56.88 96.26,55.81 94.13,53.68 90.98,53.68 89.45,55.2 89.45,58.07 88.94,58.58 88.34,58.58 88.11,58.81 85.85,58.81 84.56,57.52 84.56,56.71 83.69,55.84 81.79,55.84 76.95,50.99 75.01,50.99 73.42,49.4 72.59,49.4 71.98,48.79 71.98,48.27 71.04,47.34 v8(70.46,47.34)
  BOTTOM w0.117: v8(118.66,53.81) 119.5,54.65 125.25,54.65 v4(125.71,54.19) 126.39,53.51 R156.2 126.39,52.97 126.57,52.79 R164.1 ; v8(70.46,47.34) 71.02,47.34 71.05,47.31 PR99.1
VCCST_PWRGD_R: length 3.5
  TOP w0.06: v4(127.04,50.71) 126.23,49.89 126.23,49.16 126.08,49 U3.B61
  BOTTOM w0.117: v4(127.04,50.71) 126.56,51.19 v4(126.56,51.26) 126.56,51.29 126.57,51.29 R164.2
VDD_V3P3A_RTC: length 24.4
  TOP w0.305: v1(75.91,36.01) 75.91,35.16 v4(75.48,34.73) 75.08,34.73 73.32,32.98 D3.2
  IN1 w0.305: v1(75.91,36.01) 75.91,36.23 79.42,39.73 79.42,40.14 80.23,40.95 v3(80.54,40.95)
  IN2 w0.305: v3(80.54,40.95) 79.95,40.95 78.73,39.73 74.77,39.73 73.98,40.52 72.2,40.52 71.89,40.84 71.89,40.87 v9(71.77,40.99) 71.77,42.08 71.6,42.26 v3(71.52,42.26)
  GND2 w0.305: v8(71.77,40.5) v9(71.77,40.99)
