# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TXP3_C: length 1.6
  BOTTOM w0.117: U14.11 232.49,25.67 232.23,25.94 231.98,25.94 C318.2
USB_BIAS: length 6.5
  TOP w0.152: U3.N2 106.98,46.36 106.55,46.79 106.06,46.79 105.6,46.33 103.93,46.33 v4(103.68,46.09) 102.87,45.28 R53.1
USBOC01#: length 8.2
  TOP w0.117: v1(106.06,46.03) 105.69,45.66 103.74,45.66 103.55,45.48 R51.1
  IN1 w0.06: 110.51,46.36 109.45,46.36 109.21,46.59 108.98,46.59 108.77,46.39 106.78,46.39 106.42,46.03 v1(106.06,46.03)
  IN1 w0.071: v11(111.02,46.36) 110.51,46.36
USBOC23#: length 7
  TOP w0.089: v1(107.16,48.05) 107.16,48.13 106.88,48.41
  TOP w0.117: 106.88,48.41 106.57,48.72 106.03,49.26 R46.1
  IN1 w0.071: v1(107.16,48.05) 107.19,48.08 108.88,48.08 109.09,47.87 109.64,47.87 110.06,47.45 110.06,47.23 110.19,47.1 110.2,47.1 110.37,46.93 110.62,46.68 v11(110.78,46.68)
USBOC45#: length 6.3
  TOP w0.117: v3(108.53,51.17) 108.53,51.82 109.19,52.49 R33.1
  IN2 w0.094: v3(110.03,48.13) 110.03,48.18 110.31,48.45 110.31,50.19 109.9,50.59 109.31,50.59 108.73,51.17 v3(108.53,51.17)
USBP1+_POA: length 118.6
  IN1 w0.071: v1(109.16,40.56) 109,40.39 108.91,40.39 108.79,40.51 108.79,40.68 108.67,40.8 108.1,40.8 107.86,40.55 107.04,40.55 106.75,40.27 105.4,40.27 105.12,40.55 102.84,40.55 101.54,39.25 100.19,39.25 99.21,38.27 99.21,37.52 98.01,36.32 98.01,34.06 97.86,33.92 97.86,30.26 96.77,29.17 96.77,25.08 98.48,23.37 98.48,14.43 99.87,13.04 100.44,13.04 102.32,11.16 105.02,11.16 106.12,10.06 135.41,10.06 137.03,8.44 156.73,8.44 157.5,7.68 158.11,7.68 159,8.57 168.98,8.57 171.95,5.6 172.31,5.6 172.89,5.01 172.89,4.71 v2(173.04,4.55)
  GND1 w0.117: v2(173.04,4.55) 173.01,4.52 173.01,4.31 v9(173.09,4.22)
  GND2 w0.117: v9(173.09,4.22) 172.97,4.1 172.97,3.97 173.09,3.84 v8(173.35,3.84)
  BOTTOM w0.117: R1526.1 173.09,3.99 173.09,4.41 R1531.2
USBP1+_POA_R: length 14.7
  IN2 w0.094: v9(173.78,4.22) 172.94,5.07 172.94,7.15 v9(173.07,7.28) 172.96,7.39 172.96,7.61 172.62,7.95 171.38,7.95 170.22,6.79 168.78,6.79 168.67,6.9 168.67,7.14 v4(168.85,7.32)
  GND2 w0.117: v9(173.07,7.28) 172.99,7.36 172.99,8.13 v8(173.2,8.34) ; v9(173.78,4.22) v8(173.78,3.89)
  BOTTOM w0.117: CN17.2 v4(168.85,7.32) ; v8(173.2,8.34) 173.01,8.52 173.01,8.9 D49.2 ; v8(173.78,3.89) 173.63,3.74 173.63,2.45 173.48,2.3 R1528.2
USBP1+_POA_R2: length 1.1
  BOTTOM w0.117: U39.7 173.04,7.32 172.99,7.37 172.99,7.68 R1533.2
USBP1+_POA_R3: length 0.8
  BOTTOM w0.117: R1528.1 173.01,2.96 173.01,3.21 R1526.2
USBP1+_POA_U: length 1.1
  BOTTOM w0.117: U39.1 173.04,5.54 172.99,5.49 172.99,5.21 R1531.1
USBP1-_POA: length 118.7
  IN1 w0.071: v2(172.71,4.55) 172.71,4.94 172.23,5.42 171.88,5.42 168.91,8.39 159.07,8.39 158.19,7.5 157.42,7.5 156.66,8.26 136.95,8.26 135.33,9.88 106.05,9.88 104.95,10.98 102.24,10.98 100.37,12.86 99.79,12.86 98.3,14.36 98.3,23.3 96.59,25 96.59,29.24 97.68,30.33 97.68,33.99 97.83,34.14 97.83,36.4 99.03,37.6 99.03,38.34 100.11,39.43 101.46,39.43 102.77,40.73 105.19,40.73 105.48,40.44 106.67,40.44 106.96,40.73 107.79,40.73 107.83,40.77 107.89,40.77 108.05,40.93 108.73,40.93 108.86,40.8 109.24,40.8 109.48,40.56 v1(109.5,40.56)
  GND1 w0.117: v2(172.71,4.55) 172.71,4.33 v9(172.61,4.22)
  GND2 w0.117: v8(172.64,3.89) 172.64,4.2 v9(172.61,4.22)
  BOTTOM w0.117: R1527.1 172.8,4.15 172.8,4.25 R1532.2
USBP1-_POA_R: length 14.7
  IN2 w0.094: v9(171.95,4.22) 172.72,4.99 172.72,7.15 v9(172.59,7.28) 172.74,7.44 172.74,7.52 172.53,7.73 171.47,7.73 170.31,6.57 168.69,6.57 168.45,6.81 168.45,7.15 v4(168.27,7.32)
  GND2 w0.117: v9(172.59,7.28) 172.69,7.38 172.69,8.13 v8(172.49,8.34) ; v9(171.95,4.22) v8(171.95,3.89)
  BOTTOM w0.117: v8(172.49,8.34) 172.71,8.56 172.71,8.91 D50.2 ; v8(171.95,3.89) 171.95,2.63 172.28,2.3 R1529.2 ; CN17.3 168.35,7.4 v4(168.27,7.32)
USBP1-_POA_R2: length 1.1
  BOTTOM w0.117: U39.6 172.64,7.32 172.69,7.37 172.69,7.68 R1534.2
USBP1-_POA_R3: length 0.8
  BOTTOM w0.117: R1527.2 172.71,3.21 172.71,2.95 R1529.1
USBP1-_POA_U: length 1.1
  BOTTOM w0.117: R1532.1 172.69,5.16 172.69,5.49 172.64,5.54 U39.2
USBP2+: length 221.4
  IN2 w0.094: v4(267.2,26.4) 267,26.6 266.9,26.6 266.66,26.36 266.66,25.92 266.82,25.76 266.98,25.76 267.07,25.67 267.07,25.38 266.95,25.25 266.79,25.25 266.66,25.13 266.66,22.24 266.56,22.14 266.56,21.68 268.22,20.02 268.22,19.72 267.89,19.39 v3(267.89,19.25) 267.91,19.23 268.23,19.23 268.61,19.61 268.81,19.61 CN18.B6 ; v14(108.81,41.53) 108.81,41.66 108.23,42.23 108.23,42.79 108.02,43 107.7,43 107.5,43.2 107.36,43.35 107.36,47.04 107.19,47.21 107.19,47.69 106.86,48.03 106.86,54.49 111.61,59.24 142.03,59.24 142.16,59.37 158.74,59.37 166.25,51.85 173.03,51.85 176.53,55.35 195.89,55.35 196.83,54.41 197.35,54.41 202.48,49.28 202.48,30.74 204.5,28.72 248.68,28.72 248.88,28.52 249.74,28.52 249.97,28.75 249.97,29.42 250.98,30.43 254.34,30.43 257.04,33.13 v9(261.36,33.13)
  IN3 w0.094: v8(261.39,30.04) 261.49,30.14 261.49,33 v9(261.36,33.13)
  BOTTOM w0.117: v8(261.39,30.04) 261.47,30.12 262.45,30.12 262.54,30.21 263.36,30.21 263.47,30.09 263.47,28.86 265.75,26.58 267.02,26.58 v4(267.2,26.4)
USBP2-: length 221.3
  IN2 w0.094: v14(109.3,41.53) 109.25,41.53 108.45,42.32 108.45,42.88 108.11,43.22 107.79,43.22 107.66,43.36 107.58,43.44 107.58,47.14 107.41,47.3 107.41,47.78 107.08,48.12 107.08,54.39 111.7,59.02 142.13,59.02 142.25,59.15 158.65,59.15 166.16,51.63 173.12,51.63 176.62,55.13 195.8,55.13 196.74,54.19 197.26,54.19 202.26,49.19 202.26,30.65 204.41,28.5 248.59,28.5 248.79,28.3 249.84,28.3 250.19,28.66 250.19,29.32 251.07,30.21 254.43,30.21 257.13,32.91 261.07,32.91 261.23,32.75 261.49,32.75 v9(261.87,33.13) ; v4(267.2,27.03) 266.99,26.82 266.81,26.82 266.44,26.45 266.44,22.33 266.34,22.23 266.34,21.59 268,19.93 268,19.86 v3(267.89,19.75) 267.89,19.7 267.63,19.45 267.63,19.16 267.79,19.01 268.32,19.01 268.7,19.39 268.81,19.39 CN18.B7
  IN3 w0.094: v8(262.34,30.44) 261.76,30.44 261.71,30.49 261.71,32.97 v9(261.87,33.13)
  BOTTOM w0.117: v4(267.2,27.03) 267.04,26.88 265.88,26.88 263.77,28.98 263.77,30.22 263.48,30.51 262.41,30.51 v8(262.34,30.44)
USBP3+: length 217.2
  TOP w0.117: CN3.A6 267.38,33.25 267.09,33.55 266.88,33.55 266.81,33.47 266.81,33.27 266.67,33.13 266.48,33.13 266.35,33.26 266.35,33.64 266.27,33.72 266.02,33.72 v4(265.8,33.51) 265.42,33.13 264.75,33.13 263.2,34.68 262.02,34.68 261.61,34.27 260.64,34.27 260.01,33.64 260.01,33.3 260.14,33.17 260.5,33.17 260.62,33.04 260.62,32.86 260.51,32.75 260.22,32.75 260.01,32.54 260.01,31.88 260.13,31.76 v3(260.33,31.76)
  IN2 w0.064: v14(109.06,41.18) 109.06,41.01 109.12,40.95 109.27,40.95 109.33,41.01 109.33,41.27 109.52,41.46 109.52,42.2 109.72,42.4 109.72,43.09 109.42,43.4 109.42,43.92 109.3,44.05 109.21,44.05 109.21,44.05
  IN2 w0.094: 109.21,44.05 108.89,44.36 108.89,44.56 108.71,44.75 108.69,44.75 108.33,45.1 108.33,45.74 108.59,46 108.59,47.31 107.48,48.42 107.48,54.04 112.05,58.62 142.29,58.62 142.42,58.75 158.37,58.75 165.89,51.23 173.28,51.23 176.78,54.73 194.15,54.73 195.59,53.29 197.6,53.29 201.76,49.12 201.76,34.05 201.38,33.67 201.38,30.88 204.16,28.1 248.02,28.1 248.32,27.79 251.9,27.79 253.27,29.16 258.47,29.16 260.75,31.44 260.75,31.71 260.69,31.76 v3(260.33,31.76)
  BOTTOM w0.117: v4(265.8,33.51) 265.75,33.46 265.75,32.97 265.85,32.87 266.65,32.87 267.18,33.4 267.46,33.4 267.58,33.53 267.58,33.62 267.71,33.74 267.98,33.74 268.09,33.64 268.09,33.53 268.22,33.4 268.6,33.4 CN3.B6
USBP3-: length 217.2
  TOP w0.117: v3(261.28,32.16) 261.28,32.03 260.71,31.46 260,31.46 259.71,31.76 259.71,33.76 260.52,34.57 261.49,34.57 261.9,34.98 263.32,34.98 264.87,33.43 265.09,33.43 v4(265.17,33.51) 265.7,34.04 267.04,34.04 267.34,33.75 CN3.A7
  IN2 w0.064: v14(109.55,41.16) 109.55,41.31 109.65,41.4 109.65,42.14 109.85,42.35 109.85,43.14 109.54,43.45 109.54,43.98 109.37,44.15 109.37,44.2 109.36,44.21
  IN2 w0.094: v3(261.28,32.16) 260.97,31.86 260.97,31.34 258.57,28.94 253.36,28.94 251.99,27.57 248.23,27.57 247.92,27.88 204.07,27.88 201.16,30.78 201.16,33.76 201.54,34.14 201.54,49.03 197.5,53.07 195.5,53.07 194.05,54.51 176.88,54.51 173.38,51.01 165.8,51.01 158.28,58.53 142.51,58.53 142.38,58.4 112.15,58.4 107.7,53.95 107.7,48.51 108.81,47.4 108.81,45.91 108.55,45.65 108.55,45.19 108.78,44.97 108.8,44.97 109.12,44.65 109.12,44.45 109.36,44.21
  BOTTOM w0.117: CN3.B7 267.3,33.1 266.78,32.58 265.72,32.58 265.45,32.84 265.45,33.23 v4(265.17,33.51)
USBP4+: length 121.1
  IN1 w0.06: v11(108.81,42.17) 108.83,42.2 108.83,42.26 108.76,42.33 108.68,42.33 108.47,42.12 107.01,42.12 106.75,41.86 106.75,41.56 106.8,41.51 106.93,41.51 v3(107,41.59)
  IN1 w0.071: v4(16.85,19.19) 16.73,19.19 16.49,19.42 16.49,19.67 16.54,19.72 34.13,19.72 37.89,23.48 38.91,23.48 41.09,25.66 41.09,26.75 45.92,31.58 54.15,31.58 54.76,30.97 55.15,30.97 v4(55.29,30.83)
  IN2 w0.094: v3(107,41.59) 106.89,41.47 106.89,41.13 106.7,40.94 105.57,40.94 105.39,41.12 104.75,41.12 102.68,43.2 99.46,43.2 99.13,42.86 98.59,42.32 96.86,42.32 96.27,41.73 95.53,41.73 95.27,41.47 88.37,41.47 85.92,39.02 85.92,37.22 85.19,36.48 85.19,34.88 82.27,31.97 80.75,31.97 80.04,32.68 78.21,32.68 77.57,32.04 73.4,32.04 72.13,33.31 71.24,33.31 70.65,33.9 67.14,33.9 65.26,32.02 64.01,32.02 63.41,31.42 56.77,31.42 56.31,30.97 55.43,30.97 v4(55.29,30.83)
  BOTTOM w0.117: v4(16.85,19.19) 16.68,19.36 16.68,20.18 16.17,20.69 9.81,20.69 9.19,20.08 8.19,20.08 R327.2
USBP4+_L_13: length 6
  BOTTOM w0.117: CN8.3 3.33,20.2 3.47,20.06 3.76,20.06 v4(4.26,20.56) 4.26,20.18 4.39,20.06 4.8,20.06 4.99,20.24 D16.1 5.52,20.06 7.27,20.06 R327.1
USBP4-: length 121.1
  IN1 w0.06: v3(106.52,41.56) 106.63,41.67 106.63,41.91 106.96,42.24 108.42,42.24 108.63,42.45 108.81,42.45 109.09,42.17 v11(109.3,42.17)
  IN1 w0.071: v4(55.29,31.44) 55,31.15 54.83,31.15 54.22,31.76 45.85,31.76 40.91,26.82 40.91,25.73 38.83,23.65 37.81,23.65 34.05,19.89 16.46,19.89 16.32,19.75 16.32,19.39 v4(16.11,19.19)
  IN2 w0.094: v4(55.29,31.44) 55.29,31.3 55.4,31.19 56.22,31.19 56.67,31.64 63.32,31.64 63.92,32.24 65.17,32.24 67.05,34.12 70.74,34.12 71.33,33.53 72.22,33.53 73.49,32.26 77.47,32.26 78.12,32.9 80.13,32.9 80.84,32.19 82.18,32.19 84.96,34.97 84.96,36.57 85.7,37.31 85.7,39.11 88.28,41.69 95.18,41.69 95.44,41.95 96.18,41.95 96.77,42.54 98.49,42.54 99.37,43.42 102.77,43.42 104.85,41.34 105.48,41.34 105.66,41.16 106.61,41.16 106.67,41.22 106.67,41.41 v3(106.52,41.56)
  BOTTOM w0.117: v4(16.11,19.19) 16.28,19.19 16.38,19.29 16.38,20.06 16.04,20.39 9.93,20.39 9.32,19.78 8.19,19.78 R335.2
USBP4-_L_13: length 6
  BOTTOM w0.117: CN8.2 3.3,19.6 3.46,19.76 3.79,19.76 v4(4.26,19.29) 4.26,19.62 4.4,19.76 4.86,19.76 4.97,19.65 D17.1 5.5,19.76 7.3,19.76 R335.1
USBP5+: length 109.1
  IN2 w0.064: 111.36,49.57 111.36,49.54 111.4,49.49
  IN2 w0.066: v3(109.21,40.24) 109.14,40.16 109.14,39.99 109.24,39.89 109.52,39.89 110.28,40.65 110.28,41.1 110.05,41.33 110.05,43.24 109.78,43.52 109.78,43.9 109.9,44.02 109.9,44.99 110.2,45.29 110.2,45.93 111.09,46.83 111.31,46.83 111.53,47.05 111.53,47.32 111.4,47.45 111.4,49.49
  IN2 w0.094: 111.36,49.57 111.36,53.68 115.68,58 142.55,58 142.67,58.13 158.06,58.13 165.57,50.61 173.65,50.61 176.7,53.65 191.44,53.65 192.28,52.81 192.99,52.81 193.46,52.35 193.46,51.75 v4(193.64,51.57)
  BOTTOM w0.117: v4(193.64,51.57) 193.33,51.88 193.33,52.01 192.99,52.35 192.38,52.35 192.07,52.66 192.07,52.97 192.25,53.15 192.55,53.15 192.73,52.97 R162.2
USBP5+_L: length 7.3
  BOTTOM w0.117: CN6.2 197.5,51.49 197.8,51.79 197.8,52.69 197.05,53.45 195.52,53.45 195.24,53.17 194.72,53.17 194.51,52.97 194.51,52.77 D14.1 193.88,52.99 193.39,52.99 R162.1
USBP5-: length 109.1
  IN2 w0.064: 111.53,49.49 111.58,49.54 111.58,49.57
  IN2 w0.066: v3(108.73,40.24) 108.9,40.24 109.01,40.13 109.01,39.94 109.19,39.76 109.57,39.76 110.41,40.6 110.41,41.15 110.18,41.38 110.18,43.3 109.91,43.57 109.91,43.85 110.03,43.97 110.03,44.93 110.33,45.24 110.33,45.88 111.15,46.7 111.36,46.7 111.66,47 111.66,47.37 111.53,47.51 111.53,49.49
  IN2 w0.094: v4(193.03,51.57) 193.24,51.77 193.24,52.26 192.9,52.59 192.19,52.59 191.35,53.43 176.79,53.43 173.75,50.39 165.48,50.39 157.97,57.91 142.77,57.91 142.64,57.78 115.77,57.78 111.58,53.58 111.58,49.57
  BOTTOM w0.117: v4(193.03,51.57) 193.03,51.88 192.86,52.05 192.25,52.05 191.77,52.54 191.77,53.09 192.12,53.45 R165.2
USBP5-_L: length 7.3
  BOTTOM w0.117: R165.1 193.34,53.29 193.93,53.29 D15.1 194.5,53.47 195.12,53.47 195.39,53.75 197.17,53.75 198.1,52.82 CN6.3
USBP6+: length 123.7
  IN1 w0.06: v3(108.07,41.46) 108.15,41.46 108.21,41.52 108.21,41.69 108.37,41.85 108.66,41.85 108.79,41.97 109.01,41.97 109.05,41.93 v11(109.05,41.85)
  IN2 w0.094: v3(108.07,41.46) 107.95,41.58 107.62,41.58 107.29,41.91 107.29,42.53 107.06,42.76 106.74,43.09 106.74,46.79 106.57,46.95 106.57,47.44 106.24,47.77 106.24,51.02 105.62,51.64 105.62,54.29 111.18,59.86 141.78,59.86 141.9,59.99 159.01,59.99 166.53,52.47 172.15,52.47 175.7,56.02 197.34,56.02 198.04,55.33 198.04,54.61 201.54,51.1 CN1.3
USBP6-: length 123.7
  IN1 w0.06: v3(108.43,41.46) 108.33,41.56 108.33,41.64 108.42,41.73 108.89,41.73 108.97,41.65 109.14,41.65 109.34,41.85 v11(109.55,41.85)
  IN2 w0.094: CN1.5 203.38,50.88 203.08,50.88 202.97,50.76 202.97,50.45 202.89,50.38 202.64,50.38 202.57,50.45 202.57,50.82 202.51,50.88 201.45,50.88 197.82,54.51 197.82,55.24 197.25,55.8 175.79,55.8 172.24,52.25 166.44,52.25 158.92,59.77 142,59.77 141.87,59.64 111.27,59.64 105.84,54.2 105.84,51.73 106.46,51.11 106.46,47.86 106.79,47.53 106.79,47.05 106.96,46.88 106.96,43.18 107.22,42.92 107.51,42.62 107.51,42 107.72,41.8 108.1,41.8 108.43,41.47 v3(108.43,41.46)
VBSTVR1: length 5
  IN2 w0.508: 67,42.87 66.16,42.03 v4(63.77,42.03)
  BOTTOM w0.508: v4(63.77,42.03) 63.57,42.23 PR137.2
  vias: v1(67.02,43.23) v2(67.02,43.23) v3(67.02,43.23)
VBSTVR3: length 4.6
  GND1 w0.254: v2(72.1,43.22) 72.28,43.04 72.43,43.04 v9(72.46,43.02)
  IN3 w0.381: v8(73.12,42.69) 72.87,42.94 72.57,42.94 72.49,43.02 v9(72.46,43.02)
  BOTTOM w0.381: PR144.2 75.12,41.47 74.68,41.9 v4(74.68,42.22) 74.33,42.57 73.24,42.57 v8(73.12,42.69)
VBSTVR4: length 5.9
  TOP w0.064: 72.29,48.42 72.29,47.5 PU5.B3
  TOP w0.102: 72.29,48.42 72.29,48.48
  TOP w0.14: 72.29,48.48 72.62,48.81
  TOP w0.508: 72.62,48.81 v4(72.62,49.8)
  BOTTOM w0.508: PR66.2 73.98,50.93 v4(74.01,50.91) 74.01,50.63 73.27,49.89 72.71,49.89 v4(72.62,49.8)
VBSTVR5: length 5.4
  TOP w0.203: PU5.M3 66.78,47.47 v3(66.78,47.49)
  IN2 w0.381: v9(65.98,47.98) 66.51,47.98 66.78,47.71 v3(66.78,47.49)
  IN3 w0.381: v9(65.98,47.98) 65.23,47.98 v8(64.57,47.32)
  BOTTOM w0.381: PR106.2 64.5,46.08 v4(64.59,46.16) 64.5,46.24 64.5,47.25 v8(64.57,47.32)
VCONN_5V_P1: length 11
  TOP w0.381: v4(218.33,22.05) 218.81,21.57 218.81,18.14 v4(219.83,17.13) v4(220.85,16.11)
  BOTTOM w0.254: U16.6 221.47,15.86 221.23,16.11 v4(220.85,16.11) 220.97,15.98 U16.5
  BOTTOM w0.305: v4(220.85,16.11) 221.12,16.39 U40.8 ; U40.19 v4(218.33,22.05)
VCONN_5V_P2: length 5.6
  BOTTOM w0.254: U18.5 221.71,25.66 221.86,25.51 221.86,25.32 221.7,25.16 ; U40.25 222.12,24.74 221.7,25.16 ; 221.7,25.16 U18.6 221.06,24.62
  BOTTOM w0.305: U40.23 221.12,24.11 221.06,24.17 221.06,24.62
VCORE: length 0.6
  TOP w0.06: U3.V32 117.14,44.84
  BOTTOM w0.203: v8(119.63,49.13) 119.42,49.34 PR81.1
  vias: v1(117.19,45.98) v1(117.16,45.4) v1(117.16,44.84) v1(117.16,43.72) v1(117.16,43.16) v1(117.21,42.55) v1(117.21,39.2) v1(117.19,38.67) v1(117.27,42.15) v1(117.29,39.71) v1(117.7,42.6) v1(117.7,38.67) v1(117.93,46.41) v1(118.1,42.53) v1(118.2,38.64) v1(118.26,46.64) v1(118.58,46.41) v1(118.71,42.58) v1(118.69,38.67) v1(118.88,46.65) v1(119.15,42.53) v1(119.21,46.37) v1(119.18,38.66) v1(119.53,46.66) v1(119.7,42.55) v1(119.7,38.69) v1(119.85,46.9) v1(119.86,46.41) v1(120.13,46.63) v1(120.14,45.39) v1(120.13,44.84) v1(120.14,44.27) v1(120.14,43.72) v1(120.13,42.11) v1(120.13,41.5) v1(120.13,40.97) v1(120.13,40.36) v1(120.13,39.25) v1(120.08,38.72) v1(120.15,45.96) v1(120.17,43.15) v1(120.5,46.39) v1(120.82,46.65) v1(121.14,46.9) v1(121.78,46.9) v1(122.43,46.9) v2(117.19,45.98) v2(117.16,45.4) v2(117.16,44.84) v2(117.16,44.28) v2(117.16,43.72) v2(117.16,43.16) v2(117.21,42.55) v2(117.21,39.2) v2(117.19,38.67) v2(117.27,42.15) v2(117.29,39.71) v2(117.7,42.6) v2(117.7,38.67) v2(117.93,46.41) v2(118.1,42.53) v2(118.2,38.64) v2(118.26,46.64) v2(118.58,46.41) v2(118.71,42.58) v2(118.69,38.67) v2(118.88,46.65) v2(119.15,42.53) v2(119.21,46.37) v2(119.18,38.66) v2(119.53,46.66) v2(119.7,42.55) v2(119.7,38.69) v2(119.85,46.9) v2(119.86,46.41) v2(120.13,46.63) v2(120.14,45.39) v2(120.13,44.84) v2(120.14,44.27) v2(120.14,43.72) v2(120.13,42.11) v2(120.13,41.5) v2(120.13,40.97) v2(120.13,40.36) v2(120.13,39.25) v2(120.08,38.72) v2(120.15,45.96) v2(120.17,43.15) v2(120.5,46.39) v2(120.82,46.65) v2(121.14,46.9) v2(121.78,46.9) v2(122.43,46.9) v3(117.19,45.98) v3(117.16,45.4) v3(117.16,44.84) v3(117.16,43.72) v3(117.16,43.16) v3(117.21,42.55) v3(117.21,39.2) v3(117.19,38.67) v3(117.27,42.15) v3(117.29,39.71) v3(117.7,42.6) v3(117.7,38.67) v3(117.93,46.41) v3(118.1,42.53) v3(118.2,38.64) v3(118.26,46.64) v3(118.58,46.41) v3(118.71,42.58) v3(118.69,38.67) v3(118.88,46.65) v3(119.15,42.53) v3(119.21,46.37) v3(119.18,38.66) v3(119.53,46.66) v3(119.7,42.55) v3(119.7,38.69) v3(119.85,46.9) v3(119.86,46.41) v3(120.13,46.63) v3(120.14,45.39) v3(120.13,44.84) v3(120.14,44.27) v3(120.14,43.72) v3(120.13,42.11) v3(120.13,41.5) v3(120.13,40.97) v3(120.13,40.36) v3(120.13,39.25) v3(120.08,38.72) v3(120.15,45.96) v3(120.17,43.15) v3(120.5,46.39) v3(120.82,46.65) v3(121.14,46.9) v3(121.78,46.9) v3(122.43,46.9) v4(128.01,48.37) v4(131.04,49.31) v4(131.06,50.69) v4(131.06,49.99) v4(131.78,50.67) v4(131.78,49.98) v4(131.76,49.3) v4(132.05,47.99) v4(132.53,49.32) v4(132.55,50.7) v4(132.56,50.01) v4(133.35,49.3) v4(133.37,50.67) v4(133.37,49.98) v4(134.18,50.7) v4(134.19,50.01) v4(134.16,49.32) v4(135.04,50.69) v4(135.05,49.99) v4(135.02,49.31) v4(135.2,48.06) v4(136.26,50.4) v4(190.24,46.08) v4(190.9,42.17) v5(187.88,46.12) v5(187.88,45.38) v5(187.88,44.64) v5(187.88,43.91) v5(187.88,43.17) v5(187.88,42.43) v5(187.88,41.7) v5(187.88,40.96) v5(188.62,46.12) v5(188.62,45.38) v5(188.62,44.64) v5(188.62,43.91) v5(188.62,43.17) v5(188.62,42.43) v5(188.62,41.7) v5(188.62,40.96) v5(189.35,46.12) v5(189.35,45.38) v5(189.35,44.64) v5(189.35,43.91) v5(189.35,43.17) v5(189.35,42.43) v5(189.35,41.7) v5(189.35,40.96) v7(117.13,41.48) v7(117.1,40.92) v7(117.1,40.36) v7(117.13,39.8) v7(117.17,45.4) v7(117.16,44.84) v7(117.17,43.16) v7(117.19,42.27) v7(117.19,39.18) v7(117.47,46) v7(118.79,46.76) v7(118.86,47.13) v7(120.04,45.29) v7(120.04,44.15) v7(120.12,42.88) v7(120.08,42.09) v7(120.12,41.51) v7(120.06,40.98) v7(120.09,40.36) v7(120.1,39.77) v7(120.06,39.18) v8(117.13,41.48) v8(117.1,40.92) v8(117.1,40.36) v8(117.13,39.8) v8(117.17,45.4) v8(117.16,44.84) v8(117.19,42.27) v8(117.47,46) v8(118.31,46.84) v8(118.79,46.76) v8(118.86,47.13) v8(119.83,47.13) v8(120.04,44.15) v8(120.12,42.88) v8(120.08,42.09) v8(120.12,41.51) v8(120.06,40.98) v8(120.09,40.36) v8(120.1,39.77) v8(120.06,39.18) v8(120.79,47.13) v8(121.76,47.13) v8(122.72,47.15) v8(123.75,47.17) v8(124.68,47.61) v9(117.35,44.56) v9(117.35,44) v9(117.35,43.44) v9(117.32,41.76) v9(117.33,41.21) v9(117.3,40.65) v9(117.3,40.09) v9(117.35,45.68) v9(117.35,45.12) v9(117.35,42.88) v9(117.45,38.89) v9(117.95,38.89) v9(118.44,38.88) v9(118.93,38.89) v9(119.2,46.72) v9(119.43,38.88) v9(120.24,42.55) v9(120.33,45.67) v9(120.33,45.11) v9(120.33,44.56) v9(120.34,43.99) v9(120.34,43.44) v9(120.29,41.81) v9(120.34,41.23) v9(120.29,40.67) v9(120.32,40.08) v9(120.33,39.52) v9(120.32,38.97) v9(120.47,46.73) v9(121.46,46.76) v9(122.12,46.76) v9(122.76,46.77) v9(123.38,46.74) v10(118.79,46.76) v10(118.86,47.13) v11(120.17,39.81) v11(123.06,46.89)
VCORE_SVID_ALERT#: length 93.9
  IN1 w0.071: v2(126.23,50.92) 126.23,51.04 126.75,51.55 127.43,51.55 127.52,51.64 128.19,51.64 129.09,52.55 136.19,52.55 144.38,44.36 150.91,44.36 155.63,39.65 155.63,34.03 156.16,33.49 156.16,26.66 160.09,22.72 161.21,22.72 166.09,17.84 168.24,17.84 170.3,15.78 171.65,15.78 172.29,15.14 174.14,15.14 174.75,14.53 181.46,14.53 181.62,14.69 182.9,14.69 183.3,15.09 183.47,15.09 183.86,15.48 184.92,15.48 185.47,16.03 185.47,18.09 184.96,18.61 184.96,19.42 v4(184.53,19.85)
  GND1 w0.117: v9(126.16,50.05) 126.18,50.08 126.18,50.31 126.23,50.36 v2(126.23,50.92)
  GND2 w0.117: v9(126.16,50.05) 126,49.9 v8(125.72,49.9)
  BOTTOM w0.102: 184.55,19.83 184.7,19.68 PR267.2
  BOTTOM w0.117: PR259.1 184.09,20.29 v4(184.53,19.85) 184.55,19.83 ; R167.2 126.05,51.09 126.23,50.91 126.23,50.41 v8(125.72,49.9) 125.35,49.52 R170.2 125.02,49 v4(125.24,48.78)
VCORE_SVID_CLK: length 90.6
  TOP w0.089: 126.27,51.38 126.13,51.25 125.47,51.25 125.01,50.78 U3.A56
  TOP w0.117: v1(127.02,51.83) 126.72,51.83 126.27,51.38
  IN1 w0.071: v1(127.02,51.83) 127.02,52.29 127.38,52.65 128.62,52.65 128.9,52.93 136.34,52.93 144.53,44.74 151.07,44.74 156,39.81 156,34.18 156.53,33.65 156.53,26.81 160.25,23.1 161.36,23.1 166.24,18.22 168.39,18.22 170.45,16.16 171.81,16.16 172.46,15.51 174.3,15.51 174.91,14.91 181.31,14.91 181.47,15.07 182.75,15.07 183.15,15.47 183.31,15.47 183.7,15.86 184.76,15.86 185.09,16.19 185.09,17.94 184.53,18.51 v4(184.53,19.12)
  BOTTOM w0.102: 184.55,19.09 184.73,18.91 PR272.2
  BOTTOM w0.117: PR269.2 184.09,19.55 v4(184.53,19.12) 184.55,19.09
VCORE_SVID_DATA: length 93.3
  TOP w0.06: U3.A58 125.55,50.21
  TOP w0.089: v4(125.8,50.58) 125.55,50.33 125.55,50.21
  IN1 w0.071: v4(184.56,20.6) 185.33,19.82 185.33,18.76 185.85,18.25 185.85,15.88 185.07,15.11 184.03,15.11 183.64,14.71 183.46,14.71 183.06,14.31 181.83,14.31 181.67,14.16 174.59,14.16 173.99,14.76 172.06,14.76 171.42,15.4 170.15,15.4 168.08,17.47 165.93,17.47 161.05,22.35 159.93,22.35 155.78,26.5 155.78,33.34 155.25,33.87 155.25,39.49 150.76,43.98 144.22,43.98 136.03,52.17 129.28,52.17 128.37,51.27 127.68,51.27 127.59,51.18 127.01,51.18 126.36,50.53 125.85,50.53 v4(125.8,50.58)
  BOTTOM w0.117: v4(125.8,50.58) 125.55,50.58 R166.1 ; PR254.1 185.04,21.09 PR257.1 184.69,20.46 v4(184.56,20.6)
VGTA_BST1:
  vias: v4(158.62,55.28)
VOLUME-DOWN: length 52.2
  IN2 w0.094: v4(51.62,5.72) 51.24,5.34 25.92,5.34 20.97,10.29 9.69,10.29 v4(7.23,12.75)
  IN4 w0.071: v4(51.62,5.72) 51.89,5.99 51.89,8.41 v8(51.89,8.41)
  BOTTOM w0.117: v4(7.23,12.75) CN10.2
VOLUME-UP: length 56.7
  IN2 w0.094: v4(52.46,5.57) 52.02,5.13 25.85,5.13 20.87,10.11 9.14,10.11 6.85,12.4 6.85,13.59 7,13.75 v4(7.08,13.75)
  IN4 w0.071: v8(52.39,9.91) 52.39,9.74 52.62,9.51 52.62,7.32 52.17,6.87 52.17,5.86 v4(52.46,5.57)
  BOTTOM w0.117: v4(7.08,13.75) CN10.4
VOUT3.3VSW: length 3.4
  TOP w0.064: 66.75,45.48 66.78,45.46 66.79,45.46 PU5.M7
  TOP w0.102: 66.75,45.48 65.86,45.48 65.78,45.56 v2(65.73,45.56)
  GND1 w0.102: v9(65.3,45.41) 65.45,45.56 v2(65.73,45.56)
  GND2 w0.127: v9(65.3,45.41) v8(65.3,45)
  BOTTOM w0.117: v8(65.3,45) 65.45,45.15 PC99.1 v4(65.75,44.59)
VOUTLDO: length 0.8
  GND1 w0.254: v9(76.29,43.93) 76.29,43.88 v2(76.07,43.65)
  GND2 w0.254: v8(75.94,44.11) 76.11,44.11 v9(76.29,43.93)
  vias: v4(75.25,44.99)
VPROGOTP: length 2.8
  GND1 w0.127: v9(71.19,47.61) 71.02,47.44 v2(71.02,47.23)
  GND2 w0.127: v9(71.19,47.61) 70.96,47.61 70.85,47.73 v8(70.49,47.73)
  BOTTOM w0.117: PR92.1 71.35,48.51 71.19,48.35 v4(71.19,47.96) 70.8,47.96 70.57,47.73 v8(70.49,47.73)
VR_EN: length 7.9
  IN1 w0.203: v4(181.27,20.69) 181.6,20.69 182.42,19.88 182.42,18.76 v4(183.54,17.64)
  BOTTOM w0.117: v4(183.54,17.64) 183.54,17.79 v4(183.92,18.17)
  BOTTOM w0.203: PU12.41 180.12,21.02 180.46,20.69 v4(181.27,20.69) ; PR298.2 183.97,17.21 v4(183.54,17.64) 183.18,17.29 PR297.2
VR_HOT#: length 8.3
  BOTTOM w0.117: PU12.35 181.93,23.66 182.11,23.48 182.17,23.48 v4(183.24,22.4) 184.02,21.63 185.53,21.63 185.97,21.19 187.07,21.19 187.24,21.02 PR265.2
VR_RDY: length 6.2
  IN1 w0.203: v4(182.67,17.57) 180.79,19.45 v4(180.79,20.23)
  BOTTOM w0.203: PR294.2 182.23,17.23 182.56,17.57 v4(182.67,17.57) ; v4(180.79,20.23) 180.31,20.23 179.72,20.82 PU12.42
VREF1.25V: length 3.8
  TOP w0.14: PC27.1 71.34,51.2 71.92,51.2 v4(72.23,50.88) 72.23,50.45 72.02,50.24 PU5.B1
VRMP: length 6.8
  IN3 w0.203: v8(170.66,28.11) 171.5,27.27 v4(172.71,27.27)
  BOTTOM w0.203: PU12.12 174.48,26.46 v4(174.21,26.73) 173.67,27.27 v4(172.71,27.27) 172.44,27.27 PC141.2 ; PR194.1 170.5,27.96 v8(170.66,28.11)
VRON: length 155.3
  IN4 w0.071: v8(179.95,3.16) 177.41,3.16 177.29,3.28 174.44,3.28 174.11,2.96 140.4,2.96 138.33,5.02 103.48,5.02 103.28,4.82 96.06,4.82 93.86,7.02 93.86,8.78 90.5,12.15 80.55,12.15 79.38,13.31 68.26,13.31 67.75,12.8 64.12,12.8 57.52,6.2 54.86,6.2 53.97,7.09 53.97,7.82 53.53,8.26 53.53,8.82 53.68,8.97 53.68,9.53 53.59,9.62 53.59,10.19 53.46,10.32 52.27,10.32 51.18,11.41 v8(50.89,11.41)
  BOTTOM w0.117: v8(179.95,3.16) 179.95,3.54 180.33,3.92 180.33,4.68 179.44,5.57 v4(179.44,6.71) 179.44,6.97 180.21,7.73 180.21,8.9 180.84,9.54 180.84,10.36 180.19,11.01 179.59,11.01 178.68,11.92 177.67,11.92 177.54,11.79 176.4,11.79 176.27,11.92 PR492.2
VRON_R: length 12.2
  BOTTOM w0.117: PU19.4 179.49,14.98 179.8,14.67 ; PR494.2 177.16,12.08 177.26,12.17 178.56,12.17 179.57,13.19 179.57,14.44 179.8,14.67 ; 179.8,14.67 PR495.1 183.13,14.67 v4(183.95,15.49) 183.97,15.51 PR298.1
VSN_CORE: length 4
  BOTTOM w0.203: PR200.1 PC144.2 183.82,27.02 v4(183.25,26.45) 182.98,26.17 181.76,26.17 181.64,26.06 PU12.29
VSN_GT: length 4.9
  BOTTOM w0.198: PU12.52 175.72,21.15 175.67,21.09 175.46,21.09
  BOTTOM w0.203: PR275.1 173.09,19.38 173.33,19.15 PC200.1 173.68,19.82 v4(173.81,19.95) 174.25,20.39 174.25,20.65 174.7,21.09 175.46,21.09
VSN_SA: length 7.9
  IN1 w0.203: v4(176.94,19.99) 176.94,18.11 v4(178.56,16.49)
  BOTTOM w0.203: PU12.48 177.32,20.61 176.94,20.23 v4(176.94,19.99) 176.52,19.57 176.52,19.48 176.25,19.22 PC196.2 ; PR296.1 178.38,16.49 v4(178.56,16.49)
VSP_CORE: length 10.1
  TOP w0.203: v4(182.8,26.89) v4(184.24,26.89) 186.13,28.78 v4(186.7,28.78)
  BOTTOM w0.203: PU12.28 182.37,26.46 v4(182.8,26.89) ; PR197.1 187.6,27.75 187.93,28.07 187.93,29.17 187.67,29.43 PR193.1 187.35,29.43 v4(186.7,28.78)
VSP_GT: length 5.6
  BOTTOM w0.203: PR285.2 174.82,17.94 174.99,18.11 174.99,18.59 174.76,18.81 PC202.1 174.54,20.46 174.8,20.72 175.84,20.72 176.12,21 PU12.51
VSP_SA: length 7.9
  IN3 w0.203: v4(176.12,19.93) 176.12,17.51 v4(175.03,16.42)
  BOTTOM w0.203: PC195.2 176.05,19.93 v4(176.12,19.93) 176.92,20.73 PU12.49
  BOTTOM w0.254: v4(175.03,16.42) 175.66,17.05 PR284.2
VSTBY_FSPI: length 382.4
  TOP w0.305: PR15.1 v4(65.78,52.57) 65.78,53.02 v4(66.03,53.27)
  TOP w0.381: v4(155.82,46.21) 155.57,45.96 PR24.2
  TOP w0.508: v4(129.44,12.39) 129.86,12.39 129.89,12.36 130.07,12.36 130.08,12.35 132.35,12.35 132.58,12.12 143.48,12.12 143.91,12.55 154.3,12.55 v4(156.56,14.82)
  IN1 w0.254: v4(191.84,4.76) 195.02,4.76 198.24,7.98 199.51,7.98 202.1,10.57 v4(202.1,13.95)
  IN1 w0.508: v4(156.56,14.82) 157.02,14.82 159.07,16.87 167.84,16.87 169.92,14.79 v3(170.17,14.79) 170.78,14.79 172.01,13.56 183.95,13.56 v4(184.14,13.37) ; v4(158.11,34.4) 157.93,34.58 157.93,40.32 v4(158.49,40.88) ; v4(55.39,3.06) 55.39,3.32 53.82,4.89 49.54,4.89 44.88,9.55 44.74,9.55 40.74,13.55 v4(40.74,14.94) 40.74,16.31 42.14,17.72 v4(43.1,17.72)
  IN2 w0.254: v4(202.1,13.95) 202.56,14.41 214.83,14.41 v4(214.88,14.46) ; v9(170.55,14.84) 170.5,14.79 v3(170.17,14.79)
  IN2 w0.381: v4(155.82,46.21) 155.82,46.08 158.49,43.42 v4(158.49,40.88)
  IN2 w0.508: v4(51.2,23.66) 50.54,24.32 49.24,24.32 45.7,27.86 v4(45.7,28.28) 45.7,28.57 43.99,30.28 43.99,32.72 40.79,35.92 40.79,41.82 41.6,42.63 41.6,45.22 42.77,46.39 v4(43.1,46.39)
  IN3 w0.254: v9(170.55,14.84) 170.35,14.64 v8(170.35,14.43) ; v8(51.56,26.01) 52.19,26.65 57.78,26.65 58.41,27.29 v8(59.63,27.29)
  IN3 w0.305: 87.22,18.73 87.22,22.26 85.51,23.96 v8(83.38,23.96)
  IN3 w0.508: 86.3,17.81 87.22,18.73 88.74,18.73 97.81,9.66 v4(99.08,9.66) ; v4(43.1,46.39) 43.1,48.37 42.28,49.18 42.28,52.56 40.63,54.21 40.63,55.61 41.79,56.76 v4(42.27,56.76) 46.61,56.76 47.11,57.26 56.51,57.26 57.91,55.86 57.91,53.45 58.82,52.53 65.3,52.53 v4(66.03,53.27) ; v4(62.31,16.23) 62.31,15.9 62.71,15.5 66.11,15.5 66.52,15.91 67.48,15.91 69.41,17.84 72.56,17.84 73.35,17.05 85.44,17.05 85.8,17.41 ; v4(156.56,14.82) 156.23,15.15 156.23,17.96 159.3,21.03 159.3,24.26 159.81,24.77 159.81,27.36 157.35,29.83 157.35,33.64 v4(158.11,34.4)
  IN4 w0.254: v4(202.1,13.95) 201.97,14.08 200.53,14.08 199.38,12.94 197.86,12.94 196.55,14.25 185.02,14.25 v4(184.14,13.37)
  BOTTOM w0.203: R409.1 44.31,12.49 43.96,12.83 43.54,12.83 42.95,13.43 42.95,16.37 43.35,16.78 ; 58.92,16.67 58.92,16.64 ; R320.1 R321.1 ; R368.2 54.1,21.16 53.66,21.6 v4(53.38,21.6) 53.38,21.29 53.71,20.96 53.71,20.47 R330.1 ; v8(51.56,26.01) 51.48,26.09
  BOTTOM w0.305: R378.1 62.95,15.59 63.19,15.35 63.19,15.06 R384.1 ; U11.5 201.96,14.7 202.1,14.56 v4(202.1,13.95) ; 51.48,26.09 50.15,26.09 49.59,25.53 49.59,25.49 49.31,25.22 49.31,25.22 49.31,24.81 50.45,23.66 v4(51.2,23.66) 51.56,24.02 R353.1 ; U44.5 192.38,4.35 191.97,4.76 v4(191.84,4.76) ; v8(59.63,27.29) 60.34,26.58 PQ9.4 61.2,26.58 61.54,26.92 62.32,26.92 R10952.2 ; R361.1 58.92,16.67 ; v8(51.56,26.01) 51.68,26.14 PQ8.1 ; R314.1 56.89,19.95 v4(57.4,20.46) 58,20.46 58.31,20.15 R331.1 ; PU18.5 215.03,15.63 214.88,15.48 v4(214.88,14.46) 214.88,14.28 214.69,14.09 PU20.5 ; 58.92,16.64 v4(59.53,16.03) ; R483.1 56.38,4.23 56.38,3.64 R490.2 ; R386.1 v4(60.11,15.35) ; R345.1 v4(53,19.09) ; v4(55.06,17.72) 54.99,17.64 54.99,16.98 54.84,16.83 R360.1 ; R359.2 v4(53.79,18) ; R320.1 v4(50.01,21.73)
  BOTTOM w0.381: R3.1 41.41,45.46 42.34,46.39 v4(43.1,46.39) ; R490.2 55.79,3.45 v4(55.39,3.06)
  BOTTOM w0.508: R250.1 45.2,27.71 45.7,28.2 v4(45.7,28.28) ; v4(184.14,13.37) 184.14,12.63 PD2.1 ; R389.1 40.98,14.7 v4(40.74,14.94) ; R275.2 44.19,24.9 44.75,24.34 v4(44.75,24.21) ; v4(99.08,9.66) 99.71,9.02 99.71,7.86 100.32,7.25 125.65,7.25 126.13,7.73 126.13,10.98 126.84,11.69 127.88,11.69 128.55,12.36 129.41,12.36 v4(129.44,12.39) ; D22.1 60.9,12.44 v4(61.18,12.16) ; v4(62.31,16.23) R378.1
VSTBY_FSPI_R: length 0.9
  BOTTOM w0.254: U17.K4 v8(53.13,9.67) ; U17.E4 v8(53.39,12.41)
  vias: v4(43.86,17.72) v4(44.55,17.72) v4(44.8,13.44) v4(45.03,14.7) v4(45.05,15.33) v4(45.05,14.06) v4(46.96,18.4) v4(51.89,21.29) v7(50.39,12.41) v7(50.39,9.41) v7(50.89,11.93) v7(52.9,12.41) v8(50.39,12.41) v8(50.39,9.41) v8(50.89,11.93) v8(52.9,12.41) v10(50.39,12.41) v10(50.39,9.41) v10(50.89,11.93) v10(52.9,12.41)
WAKE_WLAN#: length 11.5
  BOTTOM w0.117: CN1.55 201.11,38.1 200.24,37.23 R202.2 199.3,37.11 198.91,36.72 v4(197.67,36.72) 196.68,36.72 194.75,38.65 Q13.1
WIFI_RF_KILL#_R: length 9.9
  BOTTOM w0.117: R462.2 45.2,6.18 45.2,7.23 v4(44.95,7.47) 45.2,7.72 45.2,9.41 C433.1 47.75,10.18 47.94,9.98 48.58,9.98 48.77,10.16 49.64,10.16 U17.G10
WLAN_EN: length 3.5
  TOP w0.117: PU3.3 v4(89.71,49.82)
  BOTTOM w0.117: PR70.1 PR74.1 89.48,50.05 v4(89.71,49.82) 89.94,50.05 PC89.1 v4(90.19,50.74)
WLAN_PCIE_RXN9: length 135.1
  IN2 w0.094: v4(196.79,43.42) 196.79,43.51 196.47,43.84 196.11,43.84 195.84,44.1 195.84,45.56 193.89,47.52 191.55,47.52 191.13,47.1 191.13,38.16 187.48,34.51 187.48,27.69 185.53,25.74 184.82,25.74 182.51,23.43 180.72,23.43 179.05,21.76 175.77,21.76 173.47,24.06 169.66,24.06 165,28.72 165,33.35 163.29,35.06 163.29,38.49 161.92,39.86 158.43,39.86 157.59,40.7 157.59,43.11 154.82,45.88 148.81,45.88 146.12,48.57 144.27,48.57 144.07,48.77 141.2,48.77 136.8,53.17 129.52,53.17 128.27,54.42 120.2,54.42 117.06,51.28 117.06,49.55 116.34,48.84 116.01,48.84 v3(115.99,48.82)
  BOTTOM w0.117: CN1.43 201.73,41.1 199.24,43.58 196.95,43.58 v4(196.79,43.42)
WLAN_PCIE_RXP9: length 135
  IN2 w0.094: v4(196.77,44.06) 196.2,44.06 196.07,44.19 196.07,45.65 193.98,47.74 191.46,47.74 190.91,47.19 190.91,38.25 187.26,34.6 187.26,27.79 185.43,25.96 184.73,25.96 182.42,23.65 180.63,23.65 178.96,21.98 175.86,21.98 173.56,24.28 169.75,24.28 165.22,28.81 165.22,33.44 163.51,35.16 163.51,38.59 162.01,40.08 158.52,40.08 157.81,40.79 157.81,43.2 154.91,46.1 148.9,46.1 146.21,48.79 144.36,48.79 144.16,48.99 141.3,48.99 136.9,53.39 129.61,53.39 128.36,54.64 128.17,54.64 120.1,54.64 116.83,51.37 116.83,49.64 116.25,49.06 115.95,49.06 115.87,49.14 115.87,49.24 v3(116.07,49.44)
  BOTTOM w0.117: CN1.41 203.28,41.6 202.99,41.89 202.69,41.89 202.56,41.76 202.56,41.51 202.45,41.4 201.85,41.4 199.37,43.88 196.95,43.88 v4(196.77,44.06)
WLAN_PCIE_TXN9: length 131.8
  IN2 w0.094: v3(115.99,47.96) 116.6,47.96 117.19,48.55 117.19,49.12 117.45,49.39 117.45,51.09 120.32,53.96 128.17,53.96 129.35,52.77 135.78,52.77 140.52,48.04 146.06,48.04 148.65,45.45 154.68,45.45 156.98,43.16 156.98,26.99 158.57,25.41 162.33,25.41 162.98,24.76 165.77,24.76 165.95,24.58 167.72,22.81 173.66,22.81 175.18,21.3 179.15,21.3 180.89,23.03 182.68,23.03 184.99,25.34 185.74,25.34 188.06,27.66 188.06,33.41 191.53,36.89 191.53,45.39 192.98,46.84 193.91,46.84 195.41,45.34 195.41,44.78 195.15,44.52 194.71,44.52 v4(194.56,44.36)
  BOTTOM w0.117: C126.2 198.67,44.52 194.71,44.52 v4(194.56,44.36)
WLAN_PCIE_TXN9_C: length 6.4
  BOTTOM w0.117: C126.1 199.53,44.57 199.94,44.57 200.37,44.14 v4(200.37,43.49) 201.04,43.49 201.73,42.8 202.38,42.8 202.47,42.71 202.47,42.43 202.57,42.33 202.79,42.33 202.89,42.43 202.89,42.71 202.98,42.8 203.46,42.8 CN1.37
WLAN_PCIE_TXP9: length 131.9
  IN2 w0.094: v3(115.99,47.39) 115.97,47.42 115.97,47.61 116.09,47.74 116.69,47.74 117.41,48.46 117.41,49.03 117.68,49.29 117.68,51 120.41,53.74 128.07,53.74 129.26,52.55 135.69,52.55 140.42,47.82 145.97,47.82 148.56,45.23 154.59,45.23 156.76,43.06 156.76,26.9 158.47,25.19 162.23,25.19 162.88,24.54 165.68,24.54 165.8,24.42 167.63,22.59 173.57,22.59 175.08,21.07 179.25,21.07 180.98,22.81 182.77,22.81 185.08,25.12 185.83,25.12 188.28,27.56 188.28,33.32 191.75,36.79 191.75,45.3 193.07,46.62 193.81,46.62 195.19,45.24 195.19,44.87 195.06,44.74 194.72,44.74 194.56,44.9 v4(194.56,45.18)
  BOTTOM w0.117: v4(194.56,45.18) 194.56,45 194.74,44.82 198.57,44.82 C109.2
WLAN_PCIE_TXP9_C: length 6.4
  BOTTOM w0.117: CN1.35 201.86,43.1 201.27,43.69 v4(201.27,44.39) 200.54,44.39 200.07,44.87 199.54,44.87 C109.1
WLAN_RST#: length 2.7
  TOP w0.117: R96.1 199.95,38.65 v4(200.1,38.8) 200.15,38.85 CN1.52
WRST#_8350: length 14.1
  BOTTOM w0.117: U20.H9 150.56,9.46 v4(149.57,10.45) 150.21,10.45 150.57,10.8 151.15,10.8 151.3,10.95 151.3,11.74 151.83,12.27 154.07,12.27 154.63,12.83 155.45,12.83 C412.1 R413.1 156.69,12.94 157.58,13.82 D21.2
XCLK_BIASREF: length 3.5
  TOP w0.117: R50.1 105.66,46.01 106.17,46.51 106.45,46.51 106.92,46.04 U3.P1
XDP_BPM0: length 9.6
  TOP w0.117: T5.1 127.02,53.09 126.55,52.63 126.29,52.63 v1(125.45,51.78)
  IN1 w0.06: v1(123.48,47.64) 123.84,47.64 123.85,47.65 124.23,47.65 124.56,47.98 124.82,47.98
  IN1 w0.071: v1(125.45,51.78) 125.24,51.58 125.24,50.46 125.62,50.08 125.62,48.93 125.33,48.64 125.33,48.15 125.16,47.98 124.82,47.98
XDP_BPM1: length 11.9
  TOP w0.117: T14.1 128.64,53.15 v1(128.52,53.03)
  IN1 w0.06: v1(123.07,47.39) 123.55,47.39 123.65,47.49 123.86,47.49 123.9,47.53 124.28,47.53 124.59,47.85 125.27,47.85 125.28,47.85
  IN1 w0.071: v1(128.52,53.03) 126.39,53.03 125.8,52.44 125.8,51.63 125.45,51.28 125.45,50.43 125.88,50 125.88,48.92 125.46,48.5 125.46,48.04 125.28,47.85
XDP_BPM2: length 8.3
  TOP w0.117: T2.1 125.06,54.74 125.06,53.33 123.95,52.21 123.95,50.87 123.82,50.74 v1(123.72,50.74)
  IN1 w0.06: v1(123.4,48.13) 123.4,48.36 123.63,48.6 123.7,48.6 123.86,48.76 123.86,48.99 123.8,49.06
  IN1 w0.071: 123.8,49.06 123.64,49.22 123.64,50.66 v1(123.72,50.74)
XDP_BPM3: length 2.1
  GND1 w0.127: v2(123.14,47.93) 123.14,48.41 v9(122.95,48.6)
  GND2 w0.127: v9(122.95,48.6) 122.95,48.7 v8(122.75,48.9)
  BOTTOM w0.117: T39.1 122.75,49.79 v8(122.75,48.9)
XDP_CPU_TRST#: length 2.2
  GND1 w0.127: v9(122.71,48.08) 122.68,48.11 122.13,48.11 v2(122.11,48.13)
  GND2 w0.127: v8(122.55,48.47) 122.71,48.31 v9(122.71,48.08)
  BOTTOM w0.117: R173.2 122.28,48.89 122.55,48.62 v8(122.55,48.47) 122.85,48.17 v4(122.96,48.17)
XDP_PRDY#: length 5.1
  TOP w0.117: T9.1 122.19,52.53 122.7,52.03 v1(122.7,51.25)
  IN1 w0.071: v1(123.37,48.65) 123.37,48.88 123.4,48.9 123.4,49.19 123.44,49.24 123.44,50.46 122.7,51.2 v1(122.7,51.25)
XDP_PREQ#: length 8.5
  TOP w0.117: U3.B55 124.68,50.99 125.22,51.53 125.83,51.53 127.29,52.98 127.29,53.87 127.63,54.21 127.63,55.1 T13.1
XDP_TCK_CPU: length 6.5
  TOP w0.117: R19.2 R20.1 124.73,53.61 v4(124.39,53.26) 124.39,53.06 123.64,52.31 v1(123.64,51.35)
  IN1 w0.071: v1(124.04,48.63) 124.04,49 123.94,49.1 123.94,51.05 v1(123.64,51.35)
XDP_TDI: length 4.6
  TOP w0.117: v1(122.63,50.92) 121.41,52.14 R26.1
  IN1 w0.071: v1(122.63,50.92) 122.79,50.76 122.8,50.76 123.31,50.25 123.31,49.29 123.07,49.05 v1(123.07,48.87)
XDP_TDI_CPU: length 6.3
  TOP w0.117: v1(122.32,51.7) 121.84,52.19 121.84,52.92 121.72,53.05 R26.2
  IN1 w0.06: v1(124.29,48.87) 124.29,49.13 124.12,49.29
  IN1 w0.071: 124.12,49.29 124.12,51.22 123.72,51.63 122.4,51.63 v1(122.32,51.7)
XDP_TDO: length 14.1
  TOP w0.117: R25.1 R24.2 130.87,53.61 130.7,53.77 v4(130.7,54.21) 130.49,54.42 v1(130.23,54.42) ; U3.B51 123.4,50.11 123.3,50.21 123.3,52.31 123.95,52.95 v1(123.95,53.1)
  IN1 w0.071: v1(130.23,54.42) 129.94,54.42 128.77,55.59 126.44,55.59 v1(123.95,53.1)
XDP_TDO_CPU: length 12.4
  TOP w0.117: v1(129.2,51.17) 129.2,51.32 130.96,53.07 R24.1
  IN1 w0.071: v1(122.43,47.89) 122.33,47.79 122.33,47.55 122.29,47.5 122.29,47.27 122.4,47.16 123.11,47.16 123.36,46.9 124.15,46.9 124.53,47.28 124.84,47.28 124.96,47.41 125.39,47.41 126.16,48.17 126.16,48.53 126.59,48.96 126.99,48.96 v1(129.2,51.17)
XDP_TMS: length 5.2
  TOP w0.117: R21.2 125.55,53.65 125.27,53.37 125.27,53.27 124.15,52.16 124.15,50.4 123.72,49.97 U3.A52
XDP_TMS_CPU: length 14.7
  TOP w0.076: U3.C59 125.71,49.23 125.78,49.3 125.78,50.03 126.26,50.51 126.26,50.74 126.58,51.06
  TOP w0.117: 126.58,51.06 126.89,51.37 127.3,51.37 127.71,51.78 127.71,52.51 128.24,53.04 128.24,53.86 128.01,54.08 128.01,54.81 128.77,55.57 128.77,55.99 128.14,56.62 125.98,56.62 v4(125.67,56.32) 125.34,55.99 125.34,54.5 R21.1
XTAL24_IN: length 10.5
  TOP w0.089: U3.M1 107.14,46.68
  TOP w0.117: 107.14,46.68 107.04,46.68 106.62,47.1 105.56,47.1 105.42,46.96 R49.1
  IN1 w0.071: v1(105,47.07) 104.79,47.28 103.88,47.28 v1(103.68,47.07) 103.17,47.58 101.95,47.58 101.61,47.24 v1(98.59,47.24)
XTAL24_OUT: length 8.7
  TOP w0.089: U3.L2 108.25,47 108.13,46.88 107.15,46.88 106.65,47.38
  TOP w0.117: 106.65,47.38 105.68,47.38 105.32,47.74 v1(104.97,47.74)
  IN1 w0.071: v1(100.79,48.94) 101.1,48.94 102,48.04 103.47,48.04 v1(103.69,47.82) 103.76,47.74 v1(104.97,47.74)
N16995392: length 9.2
  TOP w0.117: v1(102.51,35.11) 102.44,35.04 R118.2
  IN1 w0.071: v11(110.46,35.16) 109.86,35.16 109.65,34.95 109.49,34.95 109.34,34.8 107.97,34.8 107.23,35.54 106.02,35.54 105.69,35.21 104.05,35.21 103.72,34.89 102.73,34.89 v1(102.51,35.11)
N17028320: length 1.6
  IN2 w0.203: v9(119.22,37.38) 119.37,37.54 v3(119.53,37.54)
  GND2 w0.203: v8(118.84,37.22) 119,37.38 v9(119.22,37.38)
  BOTTOM w0.203: R10965.1 118.83,36.89 118.84,36.9 v8(118.84,37.22)
N17308324: length 6.2
  BOTTOM w0.117: v4(216.15,15.93) 215.89,16.19 215.89,17.13 215.75,17.27 PU18.4 214.35,17.27 214.29,17.33 214.29,17.69 214.53,17.92 PR328.2 PR330.1 213.71,18.62 214.27,19.19 PR326.2
N17389829: length 25.1
  TOP w0.203: R135.1 104.03,31.12 103.58,30.67 100.58,30.67 100.1,31.14 100.1,33.24 100.22,33.36 100.22,33.72 99.69,34.25 v1(99.67,34.25) ; R99.1 103.39,37.93 103.5,37.83 v1(103.5,37.53)
  IN1 w0.203: v2(104.54,37.68) 104.29,37.42 103.61,37.42 v1(103.5,37.53) 103.12,37.53 102.8,37.22 102.24,37.22 102.07,37.39 101.21,37.39 100.61,36.8 100.61,36.26 99.91,35.55 99.91,34.88 99.69,34.67 99.69,34.27 v1(99.67,34.25)
  GND1 w0.203: v2(104.54,37.68) 104.54,37.51 v9(104.68,37.36)
  IN3 w0.203: v8(107.77,37.21) 107.18,37.8 105.12,37.8 v9(104.68,37.36)
  BOTTOM w0.117: v4(104.24,38.21) 104.26,38.19 R503.2
  BOTTOM w0.203: v8(107.77,37.21) R203.1 106.59,37.5 106.22,37.5 105.86,37.85 105.02,37.85 104.9,37.73 R502.2 R503.2
N17400952: length 10.8
  TOP w0.117: R125.2 103.55,33.96 103.83,33.69 104,33.69 104.13,33.56 104.13,33.16 104.33,32.95 105.64,32.95 106.15,32.44 v1(108.86,32.44)
  IN1 w0.071: v1(108.86,32.44) 110.4,32.44 112.01,34.05 112.01,34.14 112.36,34.49 112.36,34.5 v11(112.45,34.58)
N17400953: length 8.4
  TOP w0.06: 110.1,32.85 110.19,32.85 111.31,33.97 111.62,33.97 111.95,34.31 U3.BP16
  TOP w0.117: R126.2 105.07,33.19 105.2,33.31 106.62,33.31 107.09,32.85 110.1,32.85
N17402934: length 8.7
  TOP w0.117: v1(105.54,32.7) 105.38,32.54 T35.1
  IN1 w0.06: v11(111.8,35.57) 111.7,35.57 111.15,35.01 111.15,34.7 110.06,33.61
  IN1 w0.071: v1(105.54,32.7) 105.64,32.7 106.55,33.61 110.06,33.61
N17402948: length 6.4
  IN1 w0.06: v11(112.47,35.57) 112.51,35.61 112.83,35.61 112.95,35.73 112.95,35.9 112.69,36.15
  IN1 w0.071: 112.69,36.15 112.69,36.64 112.57,36.77 112.57,36.93 112.59,36.95 112.59,37.27 v12(112.43,37.43)
  GND1 w0.06: v12(112.43,37.43) 112.19,37.2 v9(112.05,37.2)
  GND2 w0.127: v9(112.05,37.2) 112.25,37.4 v8(112.46,37.4)
  BOTTOM w0.117: T52.1 111.19,35.29 112.47,36.57 112.47,37.39 v8(112.46,37.4)
N17796697: length 1.2
  BOTTOM w0.117: R269.1 253.83,25.85 253.35,25.38 U13.29
N17797616: length 34.4
  IN4 w0.071: v8(230.65,28.3) 230.28,28.3 230.2,28.22 230.2,27.68 230.11,27.59 229.99,27.59 229.91,27.68 229.91,28.22 229.83,28.3 229.71,28.3 229.63,28.22 229.63,27.68 229.54,27.59 229.43,27.59 229.34,27.68 229.34,28.22 229.26,28.3 229.14,28.3 229.06,28.22 229.06,27.68 228.97,27.59 228.86,27.59 228.77,27.68 228.77,28.22 228.69,28.3 228.49,28.3 228.42,28.38 228.42,28.66 228.49,28.73 248.41,28.73 v8(248.58,28.56)
  BOTTOM w0.117: R260.1 230.4,28.55 v8(230.65,28.3) 230.24,28.3 230.13,28.19 Q18.1 ; v8(248.58,28.56) 248.66,28.48 248.66,28.05 248.97,27.74 R255.2
N17797655: length 31.7
  IN4 w0.071: v8(225.19,27.77) 225.6,27.36 230.6,27.36 v8(230.65,27.41) 230.65,27.96 231.29,28.6 248.22,28.6 248.51,28.31 248.72,28.31 v8(248.96,28.56)
  BOTTOM w0.117: Q18.4 227.96,26.89 228.58,26.27 229.99,26.27 230.65,26.93 v8(230.65,27.41) ; v8(248.96,28.56) 248.84,28.43 248.84,28.13 249.52,27.44 R256.2 ; R259.1 v8(225.19,27.77)
N17838884: length 3.8
  BOTTOM w0.117: U13.1 252.78,19.52 252.94,19.36 253.86,19.36 254.95,18.27 C338.1
N18498938: length 4.7
  TOP w0.117: T22.1 41.75,49.11 41.27,48.62 40.89,48.62 40.68,48.42 40.68,47.02 40.31,46.65 CN2.56
N18498955: length 3.1
  TOP w0.117: T18.1 40.33,48.6 40.33,47.35 40.12,47.15 CN2.58
N18538001: length 4.6
  BOTTOM w0.117: PQ15.2 212.72,22.33 212.97,22.08 213.61,22.08 213.73,21.95 213.73,20.78 v4(214.29,20.23) 214.5,20.02 PR326.1
N18566125: length 7.3
  IN1 w0.203: v4(209.7,24.72) 209.35,24.37 v4(206.5,24.37)
  BOTTOM w0.203: v4(209.7,24.72) PR318.2 PR321.1 209.13,23.73 208.87,23.47 PQ17.4 ; v4(206.11,23.86) 206.5,24.24 v4(206.5,24.37) 206.92,24.79 PQ14.4
N18566975: length 4.1
  BOTTOM w0.117: PQ15.6 212.07,21.44 211.32,22.19 211.32,23.35 v4(211.17,23.51) 210.56,24.11 PR318.1
N18652907:
  vias: v4(60.09,42.86)
N18652998:
  vias: v4(60.17,39.81)
N18653022: length 1.1
  BOTTOM w0.117: PR139.1 80.66,42.75 v4(80.66,43.75)
N18653045:
  vias: v4(78.1,40.77)
N18653149:
  vias: v4(68.22,39.76)
N18656165:
  vias: v4(72.92,53.19)
N18656336:
  vias: v4(63.6,48.17)
N18656394:
  vias: v4(76.45,54.67)
N18656412: length 7.7
  TOP w0.064: PU5.E3 70.74,47.45 v2(70.74,47.46)
  GND1 w0.102: v9(71.14,48.12) 71.11,48.1 71.07,48.1 70.86,47.9 70.86,47.59 v2(70.74,47.46)
  IN2 w0.094: v9(75.08,49.49) 74.49,48.91 72.03,48.91 71.24,48.12 v9(71.14,48.12)
  GND2 w0.127: v9(75.08,49.49) 75.26,49.68 v8(75.69,49.68)
  BOTTOM w0.117: v8(75.69,49.68) 75.77,49.68 76.07,49.38 76.07,49.13 v4(76.45,48.74)
N18659407: length 2.3
  TOP w0.064: PU5.J12 68.32,42.53 68.32,42.51 v2(68.29,42.48)
  GND1 w0.127: v9(68.93,42.31) 68.93,42.33 68.78,42.48 v2(68.29,42.48)
  GND2 w0.127: v8(68.65,42) 68.93,42.28 v9(68.93,42.31)
  BOTTOM w0.117: PR134.2 69.09,42.44 v8(68.65,42)
N18660009: length 5.7
  GND1 w0.127: v2(70.45,45.73) 70.55,45.73 v9(70.74,45.91)
  IN3 w0.203: v8(71.55,49.69) 71.24,49.69 70.23,48.68 70.23,48.45 70.2,48.42 70.2,46.45 v9(70.74,45.91)
  BOTTOM w0.203: PR77.2 71.73,49.38 71.55,49.56 v8(71.55,49.69)
N18660011: length 6.6
  TOP w0.06: v3(70.74,45.46) 70.52,45.24 PU5.E7
  TOP w0.117: PR13.2 69.67,50.84 v3(69.67,50.84)
  IN2 w0.094: v3(69.67,50.84) 69.96,50.55 69.96,49.96 70.35,49.57 70.35,48.72 70.29,48.66 70.29,45.91 v3(70.74,45.46)
N18660013: length 7.9
  TOP w0.254: v3(67.79,44.01) 68.01,44.23 PU5.K9
  IN2 w0.203: v3(60.93,42.83) 61.36,42.83 61.64,42.55 63.36,42.55 64.01,43.2 66.02,43.2 66.16,43.33 66.16,43.33 66.37,43.54 66.97,43.54 67.44,44.01 v3(67.79,44.01)
N18660028: length 3.2
  TOP w0.06: v2(68.27,47.46) 68.04,47.23 PU5.K3
  GND1 w0.102: v2(68.27,47.46) 67.94,47.8 v9(67.74,47.8)
  GND2 w0.127: v9(67.74,47.8) 67.72,47.8 v8(67.38,47.46)
  BOTTOM w0.203: v8(67.38,47.46) 67.36,47.49 66.49,47.49 PR102.2 66.49,47.49 65.73,47.49 PR101.2
N18660067: length 5.4
  TOP w0.064: PU5.L3 67.77,47.48 67.77,48.35 67.9,48.49
  TOP w0.102: 67.9,48.49 v2(68.02,48.61)
  GND1 w0.102: v2(68.02,48.61) 67.84,48.61 v9(67.71,48.48)
  GND2 w0.127: v9(67.71,48.48) 67.71,48.5 67.38,48.83 v8(67.38,48.86)
  BOTTOM w0.117: v4(66.92,49.94) 67.05,49.81 67.05,49.42 67.38,49.08 v8(67.38,48.86) 67.29,48.76 PR86.1 PR85.1
N18660148: length 3.2
  TOP w0.06: PU5.B13 72.02,41.89 72.18,41.72
  TOP w0.117: 72.18,41.72 v2(72.28,41.62)
  GND1 w0.127: v2(72.28,41.62) 72.28,41.44 72.31,41.42 v9(72.31,41.01)
  GND2 w0.127: v8(72.23,40.68) 72.31,40.76 v9(72.31,41.01)
  BOTTOM w0.117: PR162.2 72.46,39.38 72.23,39.61 v8(72.23,40.68)
N18660150: length 1.5
  BOTTOM w0.117: PR162.1 73.08,38.93 73.53,38.49 T42.1
N18660152: length 8
  TOP w0.102: PU5.N5 65.97,46.23 65.91,46.3 65.55,46.3
  TOP w0.117: 65.55,46.3 65.35,46.3 v3(65.35,46.29)
  IN2 w0.094: v3(65.35,46.29) 65.35,46.31 64.82,46.85 64.46,46.85 63.82,46.21 63.82,44.67 63.28,44.13 62.17,44.13 61.74,43.7 v3(60.98,43.7)
N18660154: length 0.9
  GND1 w0.06: v9(71.11,43.81) 71.02,43.9 v2(71.02,44.23)
  GND2 w0.127: v8(70.88,43.5) 70.88,43.58 v9(71.11,43.81)
N18660156: length 4.2
  TOP w0.102: PU5.L1 67.61,48.32 67.61,49.09
  TOP w0.117: 67.61,49.09 67.61,49.39 v4(67.08,49.92) 66.54,50.46 PR10.2 65.79,51.2 PR15.2
N18660158: length 5.9
  TOP w0.102: PU5.H2 69.26,47.97 69.26,48.4 69.42,48.56 v2(69.42,48.73)
  GND1 w0.102: v9(69.42,49.06) v2(69.42,48.73)
  GND2 w0.127: v9(69.42,49.06) v7(69.42,49.5)
  IN4 w0.071: v8(71.49,50.05) 71.06,49.62 70.78,49.62 70.53,49.37 69.55,49.37 v7(69.42,49.5)
  BOTTOM w0.117: v4(72.76,50.65) 72.6,50.49 PR71.2 71.93,50.49 v8(71.49,50.05)
N18660187: length 4.6
  GND1 w0.102: v9(67.79,42.51) 67.57,42.73 v2(67.52,42.73)
  GND2 w0.127: v9(67.79,42.51) 67.81,42.49 v8(67.81,42.05)
  BOTTOM w0.117: v8(67.81,42.05) 67.81,42.03 68.38,41.46 68.7,41.46 69.72,40.44 v4(69.72,40.04) 69.72,40.01 70.02,39.71 PR156.1
N18660199: length 3.4
  TOP w0.064: v2(72.85,42.13) 72.74,42.24 72.74,42.32 72.6,42.46 72.39,42.46 72.24,42.61 72.24,42.87 72.13,42.97 71.78,42.97 PU5.C11
  GND1 w0.102: v2(72.85,42.13) 72.92,42.13 v9(73.15,41.9)
  GND2 w0.127: v8(72.97,42.26) 72.97,42.05 73.12,41.9 v9(73.15,41.9)
  BOTTOM w0.117: v8(72.97,42.26) 73.1,42.13 PR138.2
N18660234: length 3.2
  TOP w0.064: 72.67,43.98 72.27,43.98 PU5.B10
  TOP w0.102: 72.67,43.98 72.83,44.14 v2(72.92,44.14)
  GND1 w0.102: v9(72.59,44.16) 72.9,44.16 v2(72.92,44.14)
  GND2 w0.127: v8(73.25,44.19) 72.62,44.19 v9(72.59,44.16)
  BOTTOM w0.117: PR127.2 73.83,44.16 v4(73.81,44.19) v8(73.25,44.19)
N18660242: length 1.3
  GND1 w0.203: v9(69.15,47.2) 69.18,47.23 v2(69.52,47.23)
  GND2 w0.203: v9(69.15,47.2) 69.39,46.97 v8(69.4,46.97)
  BOTTOM w0.203: PR108.1 69.4,46.39 v8(69.4,46.97)
N18660280: length 1.3
  GND1 w0.06: v9(67.84,45.58) 67.7,45.73 v2(67.52,45.73)
  GND2 w0.127: v8(67.77,45.18) 67.84,45.25 v9(67.84,45.58)
  BOTTOM w0.117: PR116.2 67.99,45.41 v8(67.77,45.18)
N18660346: length 1
  GND1 w0.102: v2(68.52,46.73) 68.49,46.75 v9(68.49,47.12)
  GND2 w0.127: v9(68.49,47.12) 68.13,47.49 v8(68.13,47.58)
N18660605: length 6.3
  TOP w0.064: PU5.J10 68.48,43.73 v2(68.27,43.53)
  GND1 w0.102: v2(68.27,43.53) 67.74,43.53 v9(67.71,43.5)
  GND2 w0.127: v9(67.71,43.5) 67.64,43.45 67.46,43.27 v8(67.46,43.22)
  BOTTOM w0.117: v8(67.46,43.22) 67.46,42.97 66.57,42.08 65.92,42.08 65.7,42.3 v4(65.2,42.3) 64.84,41.94 64.84,40.8 PR147.2
N18660635: length 7.8
  GND1 w0.06: v2(70.4,44.73) 70.4,44.82 v9(70.65,45.07)
  GND2 w0.127: v8(70.79,45.43) 70.65,45.29 v9(70.65,45.07)
  BOTTOM w0.117: PR76.2 74.85,49.31 v4(74.37,48.83) 74.04,48.5 74.04,48.01 73.17,47.15 73.17,45.66 73.03,45.52 72.13,45.52 71.99,45.38 70.84,45.38 v8(70.79,45.43)
N18660683: length 5.6
  TOP w0.06: 70.03,48.83 70.28,48.58 70.28,46.99 PU5.F4
  TOP w0.117: 70.03,48.83 69.88,48.97 69.7,48.97 68.24,50.44 v4(68.24,50.6) 68.12,50.73 PR12.2
N18660779: length 7.1
  TOP w0.064: 70.25,42.03 70.25,43.49 PU5.F10
  TOP w0.102: 70.25,42.03 70.25,41.72
  TOP w0.117: v2(70.3,40.86) 70.25,40.9 70.25,41.72
  GND1 w0.127: v9(69.08,40.43) 69.51,40.86 v2(70.3,40.86)
  GND2 w0.127: v8(67.71,39.99) 67.91,40.2 68.52,40.2 68.75,40.43 v9(69.08,40.43)
  BOTTOM w0.117: v8(67.71,39.99) 67.71,39.89 67.47,39.64 PR155.2 v4(67.3,39.05)
N18663981: length 35.3
  TOP w0.203: PR20.2 169.87,49.09 168.98,48.2 165.12,48.2 164.24,47.32 164.24,42.92 166.77,40.4 166.77,26.88 v4(167.51,26.14) v4(167.51,24.87)
  BOTTOM w0.203: PR240.2 170.28,23.33 170.28,23.86 PR232.2 169.57,23.51 168.24,23.51 167.51,24.24 v4(167.51,24.87)
N18663989: length 2.7
  BOTTOM w0.203: PR200.2 184.57,27.78 184.86,28.06 PR191.2 ; PR200.2 PC144.1 ; PR200.2 184.98,27.47 185.21,27.7 PC142.2
N18663991: length 4.8
  BOTTOM w0.198: PU12.13 174.75,26.86
  BOTTOM w0.203: 174.75,26.86 173.55,28.05 v4(172.94,28.05) 172.68,28.05 172.28,28.45 PC139.1 172.28,28.98 172.31,29.01 PR182.1
N18664007: length 2.2
  BOTTOM w0.117: v4(187.7,25.89) 187.7,26.02 187.27,26.45 PR197.2
  BOTTOM w0.203: PR197.2 186.75,27.3 PC143.2
N18664028: length 4.1
  BOTTOM w0.203: PC142.1 186.16,27.25 PC143.1 186.26,27.56 185.64,28.18 PR192.2 186.34,28.39 v4(186.56,28.18) 186.9,28.18 PR193.2
