# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M0_A_DQ7: length 23.6
  IN1 w0.06: v11(126.64,40.56) 126.65,40.56 126.73,40.64 126.96,40.64 127.05,40.73 127.29,40.73 127.44,40.88 127.51,40.88
  IN1 w0.089: v13(145.01,40.59) 145.42,40.19 145.42,38.47 144.65,37.7 142.83,37.7 139.33,41.2 131.48,41.2 131.16,40.88 127.51,40.88
  BOTTOM w0.147: U7A1.D9 145.39,40.21 v13(145.01,40.59)
M0_A_DQ8: length 24.8
  IN1 w0.06: v11(125.9,40.24) 126.11,40.24 126.31,40.04 126.48,40.04 126.55,40.12 127.13,40.12 127.21,40.04 127.43,40.04 127.69,40.29
  IN1 w0.089: v13(145.78,34.72) 146.21,35.14 146.21,36.7 145.82,37.09 143.1,37.09 142.99,36.99 141.87,36.99 138.9,39.96 132.58,39.96 132.25,40.29 127.69,40.29
  BOTTOM w0.147: U7A1.M8 145.9,34.72 v13(145.78,34.72)
M0_A_DQ9: length 25.2
  IN1 w0.06: v11(126.39,40.24) 126.9,40.24 127.1,40.44 127.61,40.44 127.65,40.49
  IN1 w0.089: 127.65,40.49 132.43,40.49 132.63,40.28 139.03,40.28 142.02,37.29 145.89,37.29 146.53,36.66 146.53,34.84 v13(145.8,34.11)
  BOTTOM w0.147: U7A1.P9 v13(145.8,34.11)
M0_A_DQ10: length 25
  IN1 w0.06: 128.17,38.65 126.72,38.65 126.62,38.75 126.31,38.75 126.11,38.95 v11(125.9,38.95)
  IN1 w0.089: 128.17,38.65 131.26,38.65 132.57,37.34 134.37,37.34 134.93,36.77 137.22,36.77 141.54,32.45 142.8,32.45 143.02,32.67 143.02,32.97 143.12,33.08 145.32,33.08 145.43,33.18 145.43,33.43 145.32,33.54 144.7,33.54 v13(144.19,34.05)
  BOTTOM w0.147: U7A1.N10 144.29,34.05 v13(144.19,34.05)
M0_A_DQ11: length 23.2
  IN1 w0.06: 128.16,39 128.16,39 126.74,39 126.67,39.07 126.55,39.07 126.46,39.17 126.46,39.17 126.46,39.17 126.36,39.27 v11(126.15,39.27)
  IN1 w0.089: 128.16,39 131.45,39 132.58,37.87 136.03,37.87 136.6,37.31 137.57,37.31 140.8,34.07 140.8,33.93 141.55,33.18 141.77,33.18 141.88,33.29 141.88,33.51 141.97,33.6 142.11,33.6 142.2,33.51 142.2,33.16 142.34,33.03 142.49,33.03 142.59,33.13 142.59,34.2 142.74,34.35 143.8,34.35 v13(144.16,34.71)
  BOTTOM w0.147: U7A1.M10 144.3,34.71 v13(144.16,34.71)
M0_A_DQ12: length 24
  IN1 w0.06: v11(126.15,39.92) 126.27,39.79 126.47,39.79 126.56,39.71 126.91,39.71 127.11,39.51 127.52,39.51 127.92,39.91
  IN1 w0.089: 127.92,39.91 132.02,39.91 132.6,39.34 138.64,39.34 141.73,36.25 141.73,35.96 141.84,35.85 142.05,35.85 142.16,35.96 142.16,36.27 142.27,36.38 142.43,36.38 142.54,36.27 142.54,35.87 142.65,35.76 142.81,35.76 142.92,35.87 142.92,36.08 143.03,36.18 143.96,36.18 144.05,36.27 144.33,36.27 144.64,35.96 144.64,35.03 v13(144.96,34.71)
  BOTTOM w0.147: v13(144.96,34.71) 145.26,35.01 U7A1.M9
M0_A_DQ13: length 23.5
  IN1 w0.06: v11(126.64,39.92) 127.55,39.92 127.74,40.11
  IN1 w0.089: v13(144.99,34.05) 145.42,34.49 145.42,36.11 145.23,36.3 145.17,36.37 144.84,36.37 144.63,36.58 143.83,36.58 143.61,36.36 143.25,36.36 142.93,36.68 141.74,36.68 138.77,39.65 132.61,39.65 132.15,40.11 127.74,40.11
  BOTTOM w0.147: U7A1.N9 145.3,34.36 v13(144.99,34.05)
M0_A_DQ14: length 22.2
  IN1 w0.06: 128.01,39.22 127.92,39.13 126.78,39.13 v11(126.64,39.27)
  IN1 w0.089: 128.01,39.22 131.49,39.22 132.58,38.14 136.14,38.14 136.71,37.57 137.8,37.57 140.8,34.57 140.97,34.57 141.12,34.42 141.12,33.99 141.2,33.9 141.38,33.9 141.5,34.02 141.5,34.68 141.6,34.78 141.8,34.78 141.9,34.68 141.9,33.97 142.01,33.87 142.18,33.87 142.28,33.97 142.28,34.7 142.39,34.81 143.27,34.81 v13(143.36,34.71)
  BOTTOM w0.147: U7A1.M11 143.5,34.71 v13(143.36,34.71)
M0_A_DQ15: length 22.3
  IN1 w0.06: 127.48,38.84 127.45,38.88 126.69,38.88 126.62,38.95 v11(126.39,38.95)
  IN1 w0.089: 127.48,38.84 131.34,38.84 132.58,37.6 135,37.6 135.11,37.5 135.11,37.14 135.21,37.04 135.36,37.04 135.47,37.14 135.47,37.5 135.57,37.6 135.72,37.6 135.82,37.5 135.82,37.14 135.93,37.04 137.39,37.04 141.67,32.76 142.66,32.76 142.84,32.95 142.84,33.89 142.95,33.99 v13(143.39,33.99)
  BOTTOM w0.147: U7A1.N11 143.43,33.99 v13(143.39,33.99)
M0_A_DQ16: length 28.3
  IN2 w0.06: 127.15,38.79 126.96,38.98 125.85,38.98 125.67,39.15 125.32,39.15 125.2,39.03 ; v14(124.91,38.95) 125.12,38.95 125.2,39.03
  IN2 w0.064: 125.2,39.03 125.2,39.03
  IN2 w0.109: v13(144.17,32.06) 144.15,32.04 143.88,32.04 143.81,31.96 143.81,31.7 143.63,31.53 143.15,31.53 143.02,31.65 143.02,32.05 142.93,32.14 142.84,32.14 142.75,32.05 142.75,31.77 142.67,31.68 142.58,31.68 142.49,31.77 142.49,32.65 142.41,32.72 142.3,32.72 142.22,32.65 142.22,32.25 142.13,32.16 142,32.16 141.94,32.22 141.81,32.36 141.81,32.83 141.01,33.63 140.85,33.79 140.85,34.54 138.5,36.89 137.75,36.89 136.59,38.05 133.06,38.05 132.85,38.26 130.91,38.26 130.8,38.36 130.8,38.5 130.88,38.58 131.58,38.58 131.67,38.67 131.67,38.82 131.56,38.93 128.73,38.93 128.39,38.59 127.35,38.59 127.15,38.79
  BOTTOM w0.147: U7A1.T10 144.53,32.41 144.19,32.06 v13(144.17,32.06)
M0_A_DQ17: length 28
  IN2 w0.06: 132.6,39.2 132.55,39.24 125.96,39.24 125.81,39.4 125.32,39.4 125.25,39.47 125.08,39.47 124.88,39.27 v14(124.67,39.27)
  IN2 w0.109: v13(143.41,32.71) 143.11,32.71 142.73,33.08 142.26,33.08 142.18,33.15 142.18,33.27 142.26,33.35 142.55,33.35 142.64,33.43 142.64,33.52 142.55,33.61 141.85,33.61 141.44,34.03 141.44,35.22 141.92,35.7 142.21,35.7 142.35,35.85 142.35,36.55 142.23,36.68 142,36.68 141.46,36.14 140.26,36.14 140.1,36.3 140.1,37.42 139.99,37.53 139.84,37.53 139.72,37.41 138.82,37.41 138.5,37.73 138.45,37.78 138.39,37.78 138.31,37.7 138.31,37.57 138.23,37.5 138.09,37.5 138.02,37.57 138.02,37.85 137.87,38 137.47,38 136.83,38.63 132.96,38.63 132.88,38.72 132.88,39 132.68,39.2 132.6,39.2
  BOTTOM w0.147: v13(143.41,32.71) 143.44,32.71 U7A1.R11
M0_A_DQ18: length 27.7
  IN2 w0.06: 131.32,39.72 131.21,39.6 126.13,39.6 125.82,39.92 v14(125.16,39.92)
  IN2 w0.109: v13(145.01,32.71) 144.68,32.71 144.57,32.81 144.57,36.23 144.49,36.3 143.78,36.3 143.71,36.38 143.71,36.56 143.78,36.63 144.55,36.63 144.62,36.71 144.62,37.09 144.55,37.17 143.43,37.17 140.79,39.81 131.41,39.81 131.32,39.72
  BOTTOM w0.147: v13(145.01,32.71) 145.37,33.06 U7A1.R9
M0_A_DQ19: length 28.1
  IN2 w0.06: v14(124.67,39.92) 124.77,40.02 124.98,40.02 125.08,40.12 125.24,40.12 125.32,40.04 125.89,40.04 126.21,39.72 130.97,39.72 131.03,39.78
  IN2 w0.109: 131.03,39.78 131.35,40.1 140.91,40.1 143.55,37.46 145.06,37.46 145.4,37.12 145.4,32.48 v13(145,32.08)
  BOTTOM w0.147: U7A1.T9 145.37,32.41 145.04,32.08 v13(145,32.08)
M0_A_DQ20: length 27.9
  IN2 w0.06: 127.17,39.07 127.12,39.12 125.9,39.12 125.75,39.27 v14(125.16,39.27)
  IN2 w0.109: 127.17,39.07 127.3,39.07 127.35,39.02 127.35,38.86 127.44,38.77 127.54,38.77 127.64,38.87 127.64,38.97 127.74,39.07 127.86,39.07 127.96,38.97 127.96,38.86 128.05,38.77 128.17,38.77 128.26,38.86 128.26,39 128.37,39.1 132.46,39.1 132.63,38.93 132.63,38.83 132.56,38.76 131.92,38.76 131.85,38.68 131.85,38.54 131.92,38.46 132.9,38.46 133.02,38.34 136.71,38.34 137.87,37.18 138.64,37.18 138.7,37.12 139.64,37.12 139.73,37.03 139.73,36.92 139.64,36.83 139.3,36.83 139.21,36.74 139.21,36.63 139.3,36.54 139.69,36.54 139.8,36.43 139.8,36.01 140.04,35.77 140.47,35.77 140.56,35.68 140.56,35.26 140.64,35.19 140.78,35.19 140.85,35.26 140.85,35.6 140.94,35.69 141.06,35.69 141.15,35.6 141.15,33.91 142.15,32.91 142.56,32.91 142.77,32.7 142.77,32.49 142.9,32.36 143.31,32.36 143.4,32.27 v13(143.4,32.01)
  BOTTOM w0.147: U7A1.T11 143.41,32.03 v13(143.4,32.01)
M0_A_DQ21: length 28.2
  IN2 w0.06: 127.21,38.48 126.84,38.86 125.8,38.86 125.7,38.95 v14(125.41,38.95)
  IN2 w0.109: 127.21,38.48 127.28,38.41 128.52,38.41 128.82,38.72 130.42,38.72 130.52,38.62 130.52,38.5 130.44,38.41 129.11,38.41 129,38.3 129,38.16 129.1,38.06 132.72,38.06 133.02,37.76 136.47,37.76 137.99,36.23 138.75,36.23 140.56,34.42 140.56,33.66 140.59,33.64 141.33,32.89 141.52,32.71 141.52,32.4 142.57,31.35 144.12,31.35 144.6,31.83 144.6,32.32 v13(144.21,32.71)
  BOTTOM w0.147: v13(144.21,32.71) 144.24,32.71 U7A1.R10
M0_A_DQ22: length 27.5
  IN2 w0.06: 130.92,39.97 130.79,39.84 126.28,39.84 125.89,40.24 v14(125.41,40.24)
  IN2 w0.109: v13(145.75,32.76) 146.29,33.29 146.29,36.64 145.17,37.76 143.66,37.76 141.03,40.39 131.34,40.39 130.92,39.97
  BOTTOM w0.147: U7A1.R8 145.89,32.76 v13(145.75,32.76)
M0_A_DQ23: length 29.5
  IN2 w0.06: v14(124.91,40.24) 125.12,40.24 125.32,40.44 125.88,40.44 126.36,39.96 130.55,39.96 130.68,40.09
  IN2 w0.109: 130.68,40.09 131.27,40.69 141.18,40.69 142.98,38.88 144.48,38.88 145.08,38.28 146.58,36.78 146.58,32.94 145.79,32.15 v13(145.79,32.07)
  BOTTOM w0.147: v13(145.79,32.07) 145.86,32.07 U7A1.T8
M0_A_DQ24: length 27.7
  IN2 w0.06: v14(124.67,40.56) 124.88,40.56 125.08,40.76 125.24,40.76 125.32,40.68 126.86,40.68 127.2,40.34 128.26,40.34 128.42,40.49
  IN2 w0.109: v13(144.15,41.2) 143.77,41.58 143.26,41.58 143.16,41.47 135.17,41.47 135.1,41.55 135.1,41.69 135.17,41.76 138.07,41.76 138.14,41.84 138.14,41.98 138.07,42.06 131.68,42.06 130.12,40.49 128.42,40.49
  BOTTOM w0.147: U7A1.C10 144.49,40.86 144.15,41.2 v13(144.15,41.2)
M0_A_DQ25: length 27.5
  IN2 w0.06: v14(125.16,40.56) 126.78,40.56 127.17,40.16
  IN2 w0.109: 127.17,40.16 130.27,40.16 131.87,41.76 134.69,41.76 134.77,41.69 134.77,41.55 134.69,41.47 132.15,41.47 132.07,41.4 132.07,41.26 132.15,41.18 141.57,41.18 142.01,40.75 142.54,40.75 142.65,40.64 142.65,39.89 142.72,39.81 142.96,39.81 143.04,39.89 143.04,40.81 v13(143.4,41.18)
  BOTTOM w0.147: v13(143.4,41.18) 143.4,41.18 143.72,40.86 U7A1.C11
M0_A_DQ26: length 24.8
  IN2 w0.06: v14(125.41,41.53) 126.63,41.53 127.15,42.04 127.88,42.04 127.9,42.06
  IN2 w0.109: 127.9,42.06 129.19,42.06 131.57,44.43 131.86,44.43 131.95,44.34 131.95,43.92 132.04,43.83 132.2,43.83 132.29,43.92 132.29,44.34 132.38,44.43 132.54,44.43 132.63,44.34 132.63,43.92 132.72,43.83 132.89,43.83 132.98,43.92 132.98,44.34 133.06,44.43 143.12,44.43 145.06,42.5 v13(145.06,41.85)
  BOTTOM w0.147: U7A1.B9 v13(145.06,41.85)
M0_A_DQ27: length 24.8
  IN2 w0.06: v14(124.91,41.53) 125.12,41.53 125.32,41.73 126.65,41.73 127.12,42.2 127.65,42.2
  IN2 w0.109: v13(145.81,41.9) 145.81,41.68 145.71,41.59 145.55,41.59 145.52,41.61 145.51,41.61 145.4,41.72 145.4,42.58 143.25,44.74 131.44,44.74 129.05,42.35 127.81,42.35 127.65,42.2
  BOTTOM w0.147: v13(145.81,41.9) 145.81,41.9 U7A1.B8
M0_A_DQ28: length 27.6
  IN2 w0.06: 128.47,40.8 128.14,40.47 127.26,40.47 126.84,40.88 v14(125.41,40.88)
  IN2 w0.109: v13(143.41,41.92) 143.18,41.92 143.02,41.76 138.53,41.76 138.45,41.84 138.45,41.98 138.53,42.06 142.16,42.06 142.23,42.13 142.23,42.27 142.16,42.35 131.56,42.35 131.49,42.28 131.48,42.28 130,40.8 128.47,40.8
  BOTTOM w0.147: U7A1.B11 143.8,41.54 143.41,41.92 v13(143.41,41.92)
M0_A_DQ29: length 27.8
  IN2 w0.06: v14(124.91,40.88) 125.12,40.88 125.32,41.08 128.19,41.08 128.27,41
  IN2 w0.109: 128.27,41 129.79,41 131.43,42.64 139.22,42.64 139.85,43.27 142.59,43.27 142.67,43.19 142.67,43.03 142.59,42.96 140.1,42.96 140.02,42.88 140.02,42.72 140.1,42.64 142.74,42.64 142.82,42.57 142.82,42.43 142.74,42.35 142.61,42.35 142.54,42.27 142.54,42.13 142.61,42.06 143.02,42.06 143.23,42.27 143.7,42.27 v13(144.13,41.83)
  BOTTOM w0.147: v13(144.13,41.83) 144.28,41.83 U7A1.B10
M0_A_DQ30: length 26.3
  IN2 w0.06: 127.11,42.53 126.64,42.05 125.08,42.05 124.88,41.85 v14(124.67,41.85)
  IN2 w0.109: 127.11,42.53 127.52,42.93 128.77,42.93 131.29,45.45 143.38,45.45 146.55,42.28 v13(146.55,41.19)
  BOTTOM w0.147: v13(146.55,41.19) 146.52,41.19 U7A1.C8
M0_A_DQ31: length 25.3
  IN2 w0.06: v14(125.16,41.85) 126.6,41.85 127.12,42.36 127.39,42.36
  IN2 w0.109: v13(145.82,41.21) 146.19,41.59 146.19,42.22 143.32,45.09 131.36,45.09 128.91,42.64 127.67,42.64 127.39,42.36
  BOTTOM w0.147: v13(145.82,41.21) 145.47,40.86 U7A1.C9
M0_A_DQ32: length 30.6
  IN2 w0.06: v14(124.69,36.55) 124.87,36.36 124.87,36.2 124.88,36.19 124.88,35.95 124.72,35.79 124.72,35.45 125.44,34.73 125.44,34.13 125.5,34.07 125.59,34.07 125.65,34.13 125.65,34.47 125.71,34.53 125.79,34.53 125.85,34.47 125.85,34.15 125.91,34.09 126.23,34.09 127.67,32.65 130.62,32.65 130.75,32.52
  IN2 w0.109: v13(144.21,21.9) 143.85,22.26 143.21,22.26 142.63,22.84 142.11,22.84 141.89,23.06 141.89,23.44 141.8,23.53 141.66,23.53 141.57,23.44 141.57,22.92 141.5,22.84 141.34,22.84 141.27,22.92 141.27,23.85 141.18,23.93 141.05,23.93 140.96,23.85 140.96,23.43 140.89,23.35 140.74,23.35 140.66,23.43 140.66,23.82 140.57,23.91 140.17,23.91 133.7,30.37 132.9,30.37 130.75,32.52
  BOTTOM w0.147: v13(144.21,21.9) 144.28,21.9 U6A1.F10
M0_A_DQ33: length 30.8
  IN2 w0.06: v14(124.69,37.04) 125.11,36.61 125.11,36.3 125.22,36.19 125.22,36.08 125.5,35.8 125.5,35.31 126.59,34.22 127.63,34.22 128.96,32.89 131.17,32.89 131.24,32.82
  IN2 w0.109: v13(145,22.56) 145,22.98 144.58,23.4 144.58,24.76 144.5,24.85 143.93,24.85 143.84,24.76 143.84,23.76 143.66,23.58 143.24,23.58 143,23.82 143,24.7 142.86,24.83 142.34,24.83 142.06,24.54 140.36,24.54 133.93,30.97 133.09,30.97 131.24,32.82
  BOTTOM w0.147: U6A1.E10 144.93,22.56 v13(145,22.56)
M0_A_DQ34: length 30.5
  IN2 w0.06: 129.2,31.76 129.08,31.88 126.77,31.88 124.81,33.84 124.81,34.51 124.08,35.24 124.08,35.9 124.04,35.95 v14(124.04,36.06)
  IN2 w0.109: 129.2,31.76 132.53,28.43 132.53,28.29 137.33,23.49 137.34,23.49 139.82,21.01 142.31,21.01 142.85,20.47 144.78,20.47 145.36,21.06 145.36,21.59 v13(145,21.95)
  BOTTOM w0.147: v13(145,21.95) 145.28,22.23 U6A1.E9
M0_A_DQ35: length 29.4
  IN2 w0.06: v14(124.04,36.55) 124.04,36.34 124.24,36.14 124.24,35.25 124.93,34.56 124.93,33.89 126.82,32 129.24,32 129.51,31.73
  IN2 w0.109: v13(145,21.19) 144.46,20.64 142.93,20.64 142.27,21.3 139.94,21.3 129.51,31.73
  BOTTOM w0.147: U6A1.F9 v13(145,21.19)
M0_A_DQ36: length 30.7
  IN2 w0.06: 130.98,32.67 130.88,32.77 127.79,32.77 127.73,32.83 127.73,32.92 127.79,32.98 128.41,32.98 128.47,33.04 128.47,33.12 128.41,33.18 127.41,33.18 127.35,33.24 127.35,33.32 127.41,33.38 127.98,33.38 128.04,33.44 128.04,33.53 127.98,33.59 126.91,33.59 125.38,35.11 125.38,35.75 125.04,36.09 125.04,36.2 124.99,36.25 124.99,36.53 124.77,36.75 124.69,36.75 124.4,37.04 v14(124.04,37.04)
  IN2 w0.109: 130.98,32.67 132.99,30.67 133.82,30.67 140.24,24.25 141.5,24.25 141.57,24.18 141.57,23.92 141.66,23.83 141.81,23.83 141.9,23.92 141.9,24.19 141.99,24.28 142.09,24.28 142.18,24.19 142.18,23.3 142.34,23.15 142.86,23.15 v13(143.39,22.61)
  BOTTOM w0.147: v13(143.39,22.61) 143.4,22.61 143.77,22.23 U6A1.E11
M0_A_DQ37: length 29.4
  IN2 w0.06: 130.63,32.24 130.37,32.49 127,32.49 126.94,32.55 126.94,32.64 127,32.7 127.24,32.7 127.3,32.76 127.3,32.86 126.74,33.41 126.64,33.41 126.34,33.11 126.25,33.11 126.19,33.17 126.19,33.26 126.46,33.54 126.46,33.69 126.22,33.93 125.4,33.93 125.31,34.03 125.31,34.7 124.6,35.4 124.6,35.98 v14(124.69,36.06)
  IN2 w0.109: v13(143.39,21.89) 143.78,21.89 143.86,21.82 143.86,21.6 143.79,21.54 143.02,21.54 142.89,21.67 142.75,21.8 142.75,22.28 142.56,22.48 141.18,22.48 133.58,30.08 132.79,30.08 130.63,32.24
  BOTTOM w0.147: U6A1.F11 143.76,21.58 143.45,21.89 v13(143.39,21.89)
M0_A_DQ38: length 31.5
  IN2 w0.06: 129.13,31.58 128.97,31.73 126.74,31.73 124.69,33.79 124.69,34.46 123.96,35.19 123.96,35.85 123.84,35.98 123.84,36.14 123.92,36.22 123.92,36.39 123.72,36.59 v14(123.72,36.8)
  IN2 w0.109: 129.13,31.58 132.1,28.61 132.1,28.31 132.48,27.92 137.21,23.2 139.53,20.88 139.7,20.71 142.36,20.71 142.77,20.3 144.85,20.3 145.26,20.71 145.68,20.71 145.82,20.84 v13(145.82,21.22)
  BOTTOM w0.147: v13(145.82,21.22) 146.18,21.58 U6A1.F8
M0_A_DQ39: length 33.2
  IN2 w0.06: v14(123.72,36.3) 123.72,35.93 123.84,35.8 123.84,35.13 124.57,34.4 124.57,33.74 126.71,31.6 128.86,31.6 128.94,31.52
  IN2 w0.109: 128.94,31.52 131.79,28.66 131.79,28.2 137.09,22.91 139.4,20.59 139.58,20.42 142.4,20.42 142.69,20.12 144.93,20.12 145.34,20.53 145.75,20.53 146.27,21.05 146.27,22.11 v13(145.79,22.59)
  BOTTOM w0.147: v13(145.79,22.59) 145.69,22.59 U6A1.D9
M0_A_DQ40: length 34
  IN2 w0.06: v14(123.4,37.04) 123.4,36.83 123.6,36.63 123.6,36.47 123.52,36.39 123.52,35.96 123.72,35.75 123.72,35.08 124.45,34.35 124.45,33.69 126.69,31.45 128.75,31.45 129,31.2
  IN2 w0.109: 129,31.2 131.46,28.73 131.46,27.83 136.88,22.41 139.38,19.92 145.01,19.92 145.4,19.53 145.4,18.57 145.51,18.46 145.51,17.66 v13(145.78,17.39)
  BOTTOM w0.147: U6A1.M8 145.9,17.39 v13(145.78,17.39)
M0_A_DQ41: length 33.8
  IN2 w0.06: v14(123.4,36.55) 123.4,35.91 123.6,35.71 123.6,35.03 124.33,34.3 124.33,33.64 126.64,31.33 128.61,31.33 128.85,31.1
  IN2 w0.109: 128.85,31.1 131.24,28.71 131.24,27.64 131.72,27.16 139.26,19.62 142.39,19.62 142.42,19.65 144.43,19.65 144.56,19.53 144.63,19.45 144.63,19.05 145.33,18.35 145.33,18.14 145.33,18.14 145.33,17.85 145.33,17.85 145.33,17.59 145.35,17.57 145.35,17.09 v13(144.99,16.72)
  BOTTOM w0.147: v13(144.99,16.72) 145.3,17.03 U6A1.N9
M0_A_DQ42: length 32.7
  IN2 w0.06: 127.65,30.31 127.57,30.4 126.49,30.4 123.59,33.3 123.59,34.02 123.28,34.33 122.69,34.92 122.69,35.84 122.55,35.98 122.55,36.14 122.63,36.22 122.63,36.39 122.55,36.47 122.55,36.63 122.75,36.83 v14(122.75,37.04)
  IN2 w0.109: 127.65,30.31 129.3,28.67 129.3,26.7 139.22,16.77 143,16.77 143.05,16.72 v13(143.39,16.72)
  BOTTOM w0.147: v13(143.39,16.72) 143.49,16.72 U6A1.N11
M0_A_DQ43: length 31.4
  IN2 w0.06: 128.04,30.64 126.59,30.64 123.83,33.4 123.83,34.12 122.95,35 122.95,36.14 122.75,36.34 v14(122.75,36.55)
  IN2 w0.109: 128.04,30.64 129.88,28.79 129.88,26.94 139.4,17.42 v13(143.4,17.42)
  BOTTOM w0.147: v13(143.4,17.42) 143.54,17.42 U6A1.M11
M0_A_DQ44: length 32
  GND1 w0.06: v14(123.4,35.62) v12(123.4,36.06)
  IN2 w0.06: 128.8,30.89 128.48,31.21 126.59,31.21 124.21,33.59 124.21,34.25 123.4,35.06 123.4,35.61 v14(123.4,35.62)
  IN2 w0.109: v13(144.96,17.38) 144.61,17.74 144.61,18.49 144.21,18.88 142.49,18.88 142.04,19.33 139.14,19.33 131.01,27.46 131.01,28.68 128.8,30.89
  BOTTOM w0.147: v13(144.96,17.38) 145.1,17.38 U6A1.M9
M0_A_DQ45: length 32.1
  IN2 w0.06: 127.98,30.36 127.83,30.52 126.54,30.52 123.71,33.35 123.71,34.07 123.37,34.41 122.81,34.97 122.81,35.89 122.75,35.95 v14(122.75,36.06)
  IN2 w0.109: 127.98,30.36 129.59,28.76 129.59,26.82 139.32,17.08 143.25,17.08 143.26,17.08 143.85,17.08 v13(144.16,17.38)
  BOTTOM w0.147: v13(144.16,17.38) 144.3,17.38 U6A1.M10
M0_A_DQ46: length 33.1
  IN2 w0.06: v14(122.43,36.3) 122.43,35.93 122.57,35.79 122.57,34.87 123.06,34.38 123.47,33.97 123.47,33.25 126.48,30.24 126.74,30.24
  IN2 w0.109: v13(144.19,16.72) 143.84,16.38 143.24,16.38 143.14,16.48 139.1,16.48 129,26.58 129,28.65 127.42,30.24 126.74,30.24
  BOTTOM w0.147: U6A1.N10 144.29,16.72 v13(144.19,16.72)
M0_A_DQ47: length 35.6
  IN2 w0.06: v14(122.43,36.8) 122.43,36.6 122.23,36.4 122.23,35.96 122.45,35.74 122.45,34.82 122.51,34.76 123.35,33.92 123.35,33.16 126.49,30.03 126.65,30.03
  IN2 w0.109: 126.65,30.03 127.3,30.03 128.71,28.62 128.71,26.46 138.98,16.19 141.33,16.19 142.45,15.06 143.24,15.06 143.25,15.06 143.56,15.06 143.8,15.3 143.8,15.47 144.05,15.71 144.66,15.71 v13(145.01,16.06)
  BOTTOM w0.147: v13(145.01,16.06) 145.33,16.38 U6A1.P9
M0_A_DQ48: length 28.9
  IN1 w0.06: 127.04,33.81 126.92,33.69 125.99,33.69 125.81,33.87 125.81,33.91 125.8,33.91 125.8,34.16 125.67,34.3 125.53,34.3 125.34,34.49 125.34,34.96 125.22,35.07 125.22,35.36 125.01,35.57 v11(124.69,35.57)
  IN1 w0.089: v13(145.04,24.49) 145.04,24.31 145.13,24.21 145.94,24.21 146.04,24.32 146.04,24.59 145.76,24.87 145.02,24.87 143.8,26.09 139,26.09 131,34.09 127.32,34.09 127.04,33.81
  BOTTOM w0.147: U6A1.B9 145.35,24.18 v13(145.04,24.49)
M0_A_DQ49: length 29
  IN1 w0.06: 126.99,33.23 126.77,33.45 125.89,33.45 125.05,34.29 125.05,34.5 124.69,34.86 v11(124.69,35.07)
  IN1 w0.089: v13(143.44,24.49) 143.76,24.49 143.86,24.59 143.86,25.13 143.61,25.38 142.92,25.38 142.82,25.28 142.82,24.98 142.72,24.87 142.54,24.87 142.44,24.98 142.44,25.25 142.3,25.39 138.81,25.39 130.98,33.23 130.73,33.23 130.68,33.28 130.68,33.48 130.57,33.59 130.41,33.59 130.3,33.48 130.3,33.31 130.19,33.2 130.04,33.2 129.93,33.31 129.93,33.56 129.83,33.66 129.67,33.66 129.57,33.56 129.57,33.34 129.46,33.23 129.31,33.23 129.21,33.34 129.21,33.59 129.1,33.69 128.94,33.69 128.84,33.59 128.84,33.34 128.74,33.23 128.59,33.23 128.48,33.34 128.48,33.59 128.38,33.69 128.22,33.69 128.12,33.59 128.12,33.34 128.01,33.23 127.86,33.23 127.75,33.34 127.75,33.59 127.65,33.69 127.49,33.69 127.39,33.59 127.39,33.34 127.28,33.23 126.99,33.23
  BOTTOM w0.147: v13(143.44,24.49) 143.46,24.47 143.51,24.47 U6A1.B11
M0_A_DQ50: length 27.8
  IN1 w0.06: v11(124.04,35.57) 124.14,35.47 124.2,35.47 124.3,35.57 124.4,35.57 124.6,35.37 124.99,35.37 125.06,35.29 125.06,35.06 125.21,34.91 125.21,34.3 125.38,34.13 125.47,34.13 125.5,34.16 125.58,34.16 125.65,34.09 125.65,34.01 125.6,33.96 125.6,33.91 125.94,33.57 127.05,33.57
  IN1 w0.089: 127.05,33.57 127.37,33.89 130.76,33.89 138.94,25.7 143.74,25.7 144.67,24.78 144.67,24.34 144.55,24.21 144.34,24.21 144.24,24.32 v13(144.24,24.49)
  BOTTOM w0.147: v13(144.24,24.49) 144.26,24.47 144.31,24.47 U6A1.B10
M0_A_DQ51: length 29.6
  IN1 w0.06: v11(124.04,35.07) 124.04,34.86 124.24,34.66 124.24,34.4 125.99,32.65 126.84,32.65 126.95,32.54
  IN1 w0.089: v13(144.19,23.83) 144.58,23.44 144.58,21.73 144.38,21.54 143.23,21.54 142.92,21.22 140.75,21.22 129.63,32.33 127.36,32.33 127.15,32.54 126.95,32.54
  BOTTOM w0.147: v13(144.19,23.83) 144.3,23.83 U6A1.C10
M0_A_DQ52: length 27.8
  IN1 w0.06: 127.89,33.02 126.15,33.02 124.92,34.25 124.92,34.46 124.8,34.58 v11(124.69,34.58)
  IN1 w0.089: 127.89,33.02 130.74,33.02 139.11,24.66 139.34,24.66 139.44,24.76 139.44,24.98 139.54,25.08 141.15,25.08 141.25,24.98 141.25,24.26 141.35,24.16 141.57,24.16 141.68,24.26 141.68,24.95 141.78,25.05 141.98,25.05 142.08,24.95 142.08,24.21 142.18,24.11 142.82,24.11 142.92,24.01 142.92,23.65 143.02,23.55 143.73,23.55 143.83,23.65 143.83,23.83 143.74,23.93 v13(143.39,23.93)
  BOTTOM w0.147: U6A1.C11 143.77,23.53 143.39,23.91 v13(143.39,23.93)
M0_A_DQ53: length 30.7
  IN1 w0.06: 127.13,32.11 126.71,32.53 125.94,32.53 124.04,34.43 v11(124.04,34.58)
  IN1 w0.089: 127.13,32.11 129.42,32.11 140.62,20.91 142.79,20.91 142.87,20.83 145.13,20.83 145.42,21.11 145.42,23.41 v13(144.99,23.83)
  BOTTOM w0.147: U6A1.C9 145.29,23.53 v13(144.99,23.83)
M0_A_DQ54: length 32.9
  IN1 w0.06: 127.04,31.67 126.42,32.29 125.85,32.29 123.72,34.42 v11(123.72,34.83)
  IN1 w0.089: 127.04,31.67 128.98,31.67 140.36,20.28 145.75,20.28 146.51,21.05 146.51,23.16 v13(145.84,23.83)
  BOTTOM w0.147: U6A1.B8 146.19,24.18 v13(145.84,23.83)
M0_A_DQ55: length 32.1
  IN1 w0.06: 127.08,31.89 126.57,32.41 125.9,32.41 123.84,34.46 123.84,34.67 123.92,34.74 123.92,34.91 123.72,35.11 v11(123.72,35.32)
  IN1 w0.089: 127.08,31.89 129.19,31.89 140.49,20.6 145.7,20.6 146.25,21.14 146.25,22.77 v13(145.82,23.2)
  BOTTOM w0.147: v13(145.82,23.2) 146.15,23.53 U6A1.C8
M0_A_DQ56: length 34
  IN1 w0.06: v11(123.4,35.07) 123.4,34.41 123.2,34.21 123.2,34.01 123.31,33.89 123.32,33.89 123.73,33.48 124.14,33.48 125.72,31.91 125.95,31.91 126.87,30.99
  IN1 w0.089: 126.87,30.99 128.04,30.99 139.89,19.14 141.77,19.14 142.32,18.59 144.91,18.59 145.4,18.1 145.4,15.12 v13(145.01,14.73)
  BOTTOM w0.147: v13(145.01,14.73) 145.37,15.08 U6A1.T9
M0_A_DQ57: length 35.1
  IN1 w0.06: 126.94,31.44 126.22,32.16 125.8,32.16 123.52,34.45 123.52,34.91 123.6,34.99 123.6,35.16 123.4,35.36 v11(123.4,35.57)
  IN1 w0.089: 126.94,31.44 128.47,31.44 140.15,19.77 145.94,19.77 146.48,19.23 146.48,16.11 v13(145.82,15.45)
  BOTTOM w0.147: v13(145.82,15.45) 146.18,15.08 U6A1.T8
M0_A_DQ58: length 33.9
  IN1 w0.06: v11(122.75,35.07) 122.65,34.97 122.65,34.76 122.56,34.68 122.56,34.67 122.55,34.66 122.55,33.02 122.69,32.89 122.78,32.79 123.15,32.79 123.61,32.34 124.12,32.34 124.23,32.22
  IN1 w0.089: v13(144.21,15.34) 143.93,15.06 141.5,15.06 141.4,15.16 141.4,16.36 141.29,16.47 139.85,16.47 139.28,15.91 139.13,15.91 136.18,18.86 136.18,20.19 127.84,28.52 127.84,28.62 124.23,32.22
  BOTTOM w0.147: U6A1.R10 144.6,15.7 144.24,15.34 v13(144.21,15.34)
M0_A_DQ59: length 34.8
  IN1 w0.06: v11(122.75,35.57) 123.11,35.57 123.27,35.4 123.27,35.23 123.2,35.16 123.2,34.99 123.27,34.91 123.27,34.48 123.23,34.44 123.08,34.28 123.08,33.96 123.26,33.77 123.27,33.77 123.64,33.39 123.64,33.06 123.89,32.82 124.59,32.82 125.62,31.79 125.81,31.79 126.86,30.74
  IN1 w0.089: v13(145.01,15.38) 144.61,15.78 144.61,18.06 144.33,18.34 142.11,18.34 141.62,18.83 141.37,18.83 141.27,18.73 141.27,18.38 141.16,18.27 140.92,18.27 140.81,18.38 140.81,18.76 140.74,18.83 139.76,18.83 127.85,30.74 126.86,30.74
  BOTTOM w0.147: v13(145.01,15.38) 145.37,15.73 U6A1.R9
M0_A_DQ60: length 33
  IN1 w0.06: v11(122.75,34.58) 122.67,34.5 122.67,33.85 123.05,33.48 123.05,33.07 123.66,32.46 124.25,32.46 124.34,32.37
  IN1 w0.089: 124.34,32.37 126.9,29.8 127.02,29.8 136.49,20.33 136.49,18.99 138.36,17.12 138.54,17.12 139.05,17.63 139.21,17.63 139.38,17.45 139.38,17.3 138.88,16.79 138.88,16.65 139.05,16.47 139.19,16.47 139.57,16.85 141.39,16.85 141.8,16.44 141.8,16.01 142.08,15.73 142.42,15.73 142.57,15.87 142.92,15.87 v13(143.39,15.4)
  BOTTOM w0.147: v13(143.39,15.4) 143.42,15.4 143.75,15.73 U6A1.R11
M0_A_DQ61: length 33.1
  TOP w0.06: U3.BN51 v11(123.4,34.09)
  IN1 w0.06: v11(123.4,34.09) 123.88,33.6 124.19,33.6 125.77,32.03 126.1,32.03 126.92,31.21
  IN1 w0.089: 126.92,31.21 128.26,31.21 140.02,19.46 141.91,19.46 142.46,18.9 145.58,18.9 145.67,18.99 146.01,18.99 146.21,18.79 146.21,16.43 v13(145.85,16.08)
  BOTTOM w0.147: U6A1.R8 v13(145.85,16.08)
M0_A_DQ62: length 34.8
  IN1 w0.06: 124.01,31.92 123.84,32.09 123.12,32.09 122.3,32.9 122.3,34.67 122.22,34.75 122.22,34.9 122.43,35.11 v11(122.43,35.32)
  IN1 w0.089: v13(144.21,14.73) 143.82,14.33 143.07,14.33 142.44,13.7 140.86,13.7 140.33,14.23 140.33,14.88 140.2,15.01 139.14,15.01 135.55,18.6 135.55,19.9 127.37,28.07 127.37,28.56 124.01,31.92
  BOTTOM w0.147: U6A1.T10 144.24,14.73 v13(144.21,14.73)
M0_A_DQ63: length 34.4
  IN1 w0.06: v11(122.43,34.83) 122.43,34.63 122.43,34.62 122.43,32.97 123.19,32.22 123.96,32.22 124.1,32.08
  IN1 w0.089: 124.1,32.08 127.61,28.57 127.61,28.29 135.87,20.04 135.87,18.73 139.27,15.32 140.58,15.32 140.68,15.43 140.68,15.98 140.79,16.09 140.96,16.09 141.07,15.98 141.07,14.27 141.37,13.96 142.35,13.96 143.07,14.68 v13(143.4,14.68)
  BOTTOM w0.147: U6A1.T11 143.4,14.68 v13(143.4,14.68)
M0_A_DQSN0: length 23.7
  IN1 w0.06: v11(126.15,41.21) 126.36,41.21 126.55,41.01 126.82,41.01 126.9,41.09 127.04,41.09 127.47,41.51 128.74,41.51 129.01,41.78 129.28,41.78
  IN1 w0.089: 129.28,41.78 130.45,41.78 131.03,42.36 142.11,42.36 142.21,42.26 142.21,41.94 142.11,41.84 141.24,41.84 141.01,41.62 141.01,41.14 141.24,40.92 141.89,40.92 141.96,40.84 141.96,39.94 143.38,38.52 v13(143.41,38.52)
  BOTTOM w0.147: U7A1.G11 143.8,38.23 143.7,38.13 143.51,38.13 143.41,38.23 v13(143.41,38.52)
M0_A_DQSN1: length 23.9
  IN1 w0.06: 130.68,39.66 130.66,39.66 130.63,39.64 127.97,39.64 127.72,39.39 127.06,39.39 126.86,39.59 126.39,39.59 v11(126.39,39.6)
  IN1 w0.089: v13(144.19,35.92) 144.01,35.75 144.01,35.62 143.84,35.45 141.3,35.45 141.21,35.35 140.96,35.35 140.8,35.52 140.8,35.77 140.97,35.94 140.97,36.26 140.63,36.6 140.32,36.6 140.14,36.42 139.99,36.42 139.77,36.65 139.74,36.67 139.74,36.8 139.92,36.98 139.92,37.27 139.59,37.6 139.3,37.6 139.13,37.42 138.96,37.42 138.72,37.66 138.72,37.83 138.88,37.99 138.88,38.28 138.41,38.76 137.91,38.76 137.68,38.53 137.68,38.35 137.54,38.21 136.95,38.21 136.82,38.34 136.82,38.54 136.61,38.76 132.7,38.76 131.79,39.66 130.68,39.66
  BOTTOM w0.147: U7A1.L11 143.78,35.66 143.67,35.77 143.67,35.94 143.73,36 144.11,36 v13(144.19,35.92)
M0_A_DQSN2: length 31.3
  IN2 w0.06: v14(124.91,39.6) 124.9,39.6 124.81,39.68 124.81,39.73 124.89,39.81 124.98,39.81 125.08,39.72 125.24,39.72 125.32,39.79 125.5,39.79 125.58,39.71 125.85,39.71 126.08,39.48 132.79,39.48 132.94,39.33 133.06,39.33
  IN2 w0.114: 133.06,39.33 137.47,39.33 137.69,39.11 137.69,38.79 137.79,38.69 138.08,38.69 138.18,38.79 138.18,39.11 138.4,39.33 138.85,39.33 139.07,39.11 139.07,38.21 139.18,38.11 139.47,38.11 139.57,38.21 139.57,39.11 139.79,39.33 140.58,39.33 140.8,39.11 140.8,36.94 140.9,36.84 141.19,36.84 141.29,36.94 141.29,37.92 141.47,38.11 141.75,38.11 143.03,36.83 143.03,35.22 142.84,35.03 142.23,35.03 142.13,34.93 142.13,34.31 142.27,34.17 142.77,34.17 143.04,33.9 143.04,33.5 143.16,33.38 143.35,33.38 v13(143.4,33.42)
  BOTTOM w0.147: v13(143.4,33.42) 143.59,33.42 143.8,33.63 U7A1.P11
M0_A_DQSN3: length 28
  IN2 w0.06: v14(125.16,41.21) 127.55,41.21 127.78,41.43 128.17,41.43 128.23,41.38 128.24,41.38
  IN2 w0.114: 128.24,41.38 129.47,41.38 131.23,43.14 133.39,43.14 133.58,43.32 133.58,43.57 133.68,43.67 133.97,43.67 134.07,43.57 134.07,43.33 134.29,43.11 134.74,43.11 134.96,43.33 134.96,43.64 135.07,43.75 135.36,43.75 135.46,43.64 135.46,43.33 135.68,43.11 136.13,43.11 136.35,43.33 136.35,43.64 136.45,43.75 136.74,43.75 136.84,43.64 136.84,43.33 137.06,43.11 137.52,43.11 137.74,43.33 137.74,43.64 137.84,43.75 138.13,43.75 138.23,43.64 138.23,43.33 138.45,43.11 138.91,43.11 139.13,43.33 139.13,43.66 139.22,43.76 142.77,43.76 144.5,42.03 144.5,41.06 144.29,40.85 143.96,40.85 143.85,40.74 143.85,40.48 143.78,40.42 143.59,40.42 v13(143.41,40.59)
  BOTTOM w0.147: v13(143.41,40.59) 143.41,40.38 143.58,40.21 U7A1.D11
M0_A_DQSN4: length 33
  IN2 w0.06: 129.8,32.13 129.67,32.25 126.9,32.25 125.19,33.97 125.19,34.65 124.48,35.35 124.48,36.14 124.59,36.25 124.59,36.36 124.36,36.59 v14(124.36,36.8)
  IN2 w0.114: v13(143.38,21.19) 143.23,21.04 143.1,21.04 142.39,21.75 142.39,21.76 142.14,22.01 140.17,22.01 139.99,22.19 139.99,22.34 140.13,22.48 140.13,22.87 139.78,23.22 139.45,23.22 139.28,23.06 139.12,23.06 138.92,23.27 138.92,23.43 139.08,23.59 139.08,23.92 138.75,24.25 138.42,24.25 138.26,24.08 138.1,24.08 137.89,24.29 137.89,24.45 138.05,24.62 138.05,24.95 137.73,25.27 137.4,25.27 137.24,25.11 137.07,25.11 136.87,25.32 136.87,25.48 137.03,25.64 137.03,25.97 136.7,26.3 136.37,26.3 136.21,26.13 136.05,26.13 135.84,26.34 135.84,26.5 136,26.67 136,27 135.68,27.32 135.35,27.32 135.19,27.16 135.03,27.16 134.82,27.37 134.82,27.53 134.98,27.69 134.98,28.02 134.65,28.35 134.32,28.35 134.16,28.18 134,28.18 133.79,28.39 133.79,28.55 133.96,28.71 133.96,29.04 133.5,29.5 132.68,29.5 130.37,31.81 130.12,31.81 129.8,32.13
  BOTTOM w0.147: U6A1.G11 143.8,20.78 143.7,20.68 143.48,20.68 143.38,20.78 v13(143.38,21.19)
M0_A_DQSN5: length 33.2
  IN2 w0.06: v14(123.07,36.3) 123.07,35.04 123.96,34.16 123.96,33.47 126.56,30.87 128.11,30.87 128.14,30.85
  IN2 w0.114: v13(143.39,17.99) 143.39,17.9 143.53,17.76 143.68,17.76 143.84,17.91 143.84,18.22 143.68,18.37 142.01,18.37 141.93,18.29 141.93,18.13 141.71,17.91 141.25,17.91 141.03,18.13 141.03,18.37 140.93,18.47 140.63,18.47 140.54,18.39 140.54,18.13 140.32,17.91 139.89,17.91 139.67,18.13 139.67,18.34 139.61,18.4 139.11,18.4 135.04,22.47 131.03,26.47 130.35,27.16 130.35,28.72 129.9,29.16 128.22,30.85 128.14,30.85
  BOTTOM w0.147: U6A1.L11 143.46,17.99 v13(143.39,17.99)
M0_A_DQSN6: length 32.5
  IN1 w0.06: 127.84,32.59 127.61,32.59 127.43,32.77 126.04,32.77 124.36,34.45 v11(124.36,34.83)
  IN1 w0.089: v13(144.19,22.56) 143.66,23.1 143.02,23.1 142.9,22.98 142.9,21.92 142.68,21.7 142.2,21.7 141.98,21.92 141.98,23.3 141.88,23.4 141.56,23.4 141.43,23.27 141.43,22.18 141.23,21.98 140.76,21.98 140.56,22.18 140.56,24.25 140.43,24.38 140.11,24.38 139.98,24.25 139.98,23.75 139.78,23.55 139.21,23.55 130.17,32.59 127.84,32.59
  BOTTOM w0.147: v13(144.19,22.56) 144.12,22.49 143.98,22.49 143.94,22.54 143.86,22.54 143.8,22.6 U6A1.D11
M0_A_DQSN7: length 33
  IN1 w0.06: 126.81,30.28 126.77,30.32 126.77,30.34 125.68,31.44 125.52,31.44 124.38,32.58 123.71,32.58 123.23,33.06 123.23,33.46 122.84,33.86 122.84,34.38 122.95,34.5 122.95,34.66 122.87,34.74 122.87,34.91 123.07,35.11 v11(123.07,35.32)
  IN1 w0.089: 126.81,30.28 126.94,30.15 127.45,30.15 137.33,20.27 137.33,20.07 137.04,19.78 137.04,19.47 137.38,19.12 137.7,19.12 137.99,19.42 138.15,19.42 138.36,19.21 138.36,19.05 137.92,18.62 137.92,18.34 138.28,17.99 138.57,17.99 139,18.42 139.19,18.42 140.21,17.39 141.93,17.39 143.35,15.97 v13(143.4,15.97)
  BOTTOM w0.147: v13(143.4,15.97) 143.4,15.99 U6A1.P11
M0_A_DQSP0: length 23.7
  IN1 w0.06: v11(126.64,41.21) 126.99,41.21 127.42,41.63 128.69,41.63 128.96,41.9 129.21,41.9 129.27,41.96 129.28,41.96
  IN1 w0.089: 129.28,41.96 130.37,41.96 130.96,42.54 142.18,42.54 142.39,42.34 142.39,41.87 142.18,41.66 141.31,41.66 141.19,41.55 141.19,41.21 141.31,41.09 141.97,41.09 142.14,40.92 142.14,40.01 143.28,38.87 143.82,38.87 v13(144.17,38.52)
  BOTTOM w0.147: U7A1.G10 144.43,38.26 v13(144.17,38.52)
M0_A_DQSP1: length 23.8
  IN1 w0.06: v11(125.9,39.6) 126.02,39.47 126.23,39.47 126.31,39.4 126.47,39.4 126.55,39.47 126.81,39.47 127.01,39.27 127.77,39.27 128.02,39.52 130.63,39.52 130.66,39.49 130.68,39.49
  IN1 w0.089: 130.68,39.49 131.72,39.49 132.62,38.58 136.53,38.58 136.65,38.47 136.65,38.26 136.88,38.03 137.61,38.03 137.85,38.27 137.85,38.45 137.98,38.58 138.33,38.58 138.71,38.21 138.71,38.06 138.54,37.9 138.54,37.59 138.89,37.25 139.2,37.25 139.37,37.42 139.52,37.42 139.74,37.19 139.74,37.05 139.56,36.87 139.56,36.6 139.64,36.52 139.92,36.24 140.21,36.24 140.39,36.42 140.55,36.42 140.79,36.18 140.79,36.02 140.62,35.84 140.62,35.45 140.89,35.18 141.28,35.18 141.38,35.27 v13(144.19,35.27)
  BOTTOM w0.147: U7A1.L10 144.21,35.27 v13(144.19,35.27)
M0_A_DQSP2: length 31.3
  IN2 w0.06: 133.14,39.13 132.97,39.13 132.74,39.36 126.03,39.36 125.8,39.6 v14(125.41,39.6)
  IN2 w0.114: 133.14,39.13 137.38,39.13 137.48,39.02 137.48,38.71 137.7,38.49 138.16,38.49 138.38,38.71 138.38,39.02 138.48,39.12 138.77,39.12 138.87,39.02 138.87,38.12 139.09,37.9 139.55,37.9 139.77,38.12 139.77,39.02 139.87,39.12 140.49,39.12 140.59,39.02 140.59,36.85 140.81,36.63 141.27,36.63 141.49,36.85 141.49,37.84 141.56,37.9 141.67,37.9 142.82,36.75 142.82,35.3 142.75,35.23 142.15,35.23 141.93,35.01 141.93,34.22 142.18,33.97 142.68,33.97 142.84,33.81 142.84,33.41 143.18,33.07 143.83,33.07 v13(144.19,33.43)
  BOTTOM w0.147: U7A1.P10 144.32,33.43 v13(144.19,33.43)
M0_A_DQSP3: length 28
  IN2 w0.06: v14(124.67,41.21) 124.88,41.21 125.08,41.41 125.25,41.41 125.33,41.33 127.5,41.33 127.73,41.55 128.21,41.55 128.24,41.58
  IN2 w0.114: v13(144.2,40.5) 144.35,40.65 144.38,40.65 144.7,40.97 144.7,42.12 142.85,43.96 139.14,43.96 138.92,43.75 138.92,43.42 138.82,43.31 138.53,43.31 138.43,43.42 138.43,43.73 138.21,43.95 137.76,43.95 137.54,43.73 137.54,43.42 137.44,43.31 137.15,43.31 137.05,43.42 137.05,43.73 136.83,43.95 136.37,43.95 136.15,43.73 136.15,43.42 136.05,43.31 135.76,43.31 135.66,43.42 135.66,43.73 135.44,43.95 134.98,43.95 134.76,43.73 134.76,43.42 134.66,43.31 134.37,43.31 134.27,43.42 134.27,43.65 134.05,43.87 133.59,43.87 133.37,43.65 133.37,43.4 133.31,43.34 131.15,43.34 129.39,41.58 128.24,41.58
  BOTTOM w0.147: U7A1.D10 144.31,40.5 v13(144.2,40.5)
M0_A_DQSP4: length 33
  IN2 w0.06: 129.65,32 129.65,32.07 129.59,32.13 126.85,32.13 125.07,33.92 125.07,34.6 124.36,35.3 v14(124.36,36.3)
  IN2 w0.114: v13(144.2,21.17) 143.87,20.84 143.01,20.84 142.04,21.81 140.09,21.81 139.79,22.11 139.79,22.43 139.92,22.56 139.92,22.79 139.69,23.02 139.53,23.02 139.37,22.86 139.04,22.86 138.71,23.18 138.71,23.51 138.88,23.68 138.88,23.84 138.67,24.04 138.51,24.04 138.34,23.88 138.01,23.88 137.69,24.21 137.69,24.54 137.85,24.7 137.85,24.86 137.64,25.07 137.48,25.07 137.32,24.91 136.99,24.91 136.66,25.23 136.66,25.56 136.83,25.73 136.83,25.89 136.62,26.09 136.46,26.09 136.3,25.93 135.97,25.93 135.64,26.26 135.64,26.59 135.8,26.75 135.8,26.91 135.59,27.12 135.43,27.12 135.27,26.96 134.94,26.96 134.61,27.28 134.61,27.61 134.78,27.77 134.78,27.94 134.57,28.14 134.41,28.14 134.25,27.98 133.92,27.98 133.59,28.31 133.59,28.64 133.75,28.8 133.75,28.96 133.42,29.29 132.6,29.29 130.33,31.56 130.08,31.56 129.65,32
  BOTTOM w0.147: v13(144.2,21.17) 144.44,20.93 U6A1.G10
M0_A_DQSP5: length 33.2
  IN2 w0.06: 128.14,31.02 128.11,30.99 126.61,30.99 124.08,33.52 124.08,34.21 123.19,35.09 123.19,36.14 123.27,36.22 123.27,36.39 123.07,36.59 v14(123.07,36.8)
  IN2 w0.114: 128.14,31.02 128.29,31.02 130.55,28.76 130.55,27.24 131.18,26.62 139.19,18.6 139.69,18.6 139.87,18.43 139.87,18.22 139.97,18.12 140.24,18.12 140.34,18.22 140.34,18.47 140.54,18.68 141.01,18.68 141.24,18.46 141.24,18.22 141.34,18.12 141.62,18.12 141.73,18.22 141.73,18.37 141.93,18.57 143.77,18.57 144.04,18.3 144.04,18.14 v13(144.19,17.99)
  BOTTOM w0.147: v13(144.19,17.99) 144.26,17.99 U6A1.L10
M0_A_DQSP6: length 32.5
  IN1 w0.06: v11(124.36,35.32) 124.36,35.11 124.56,34.91 124.56,34.74 124.48,34.66 124.48,34.5 126.09,32.89 127.48,32.89 127.6,32.77 127.84,32.77
  IN1 w0.089: 127.84,32.77 130.25,32.77 139.28,23.73 139.71,23.73 139.81,23.83 139.81,24.33 140.04,24.56 140.5,24.56 140.73,24.33 140.73,22.26 140.83,22.16 141.15,22.16 141.25,22.26 141.25,23.35 141.48,23.58 141.95,23.58 142.16,23.37 142.16,21.99 142.27,21.88 142.61,21.88 142.73,21.99 142.73,23.06 142.95,23.27 143.73,23.27 143.78,23.22 v13(144.21,23.22)
  BOTTOM w0.147: v13(144.21,23.22) 144.26,23.22 U6A1.D10
M0_A_DQSP7: length 33.1
  IN1 w0.06: v11(123.07,34.83) 123.07,34.45 122.96,34.33 122.96,33.91 123.35,33.51 123.35,33.11 123.76,32.7 124.43,32.7 125.57,31.56 125.73,31.56 126.88,30.4 126.94,30.4
  IN1 w0.089: 126.94,30.4 127.01,30.33 127.52,30.33 137.51,20.34 137.51,20 137.22,19.71 137.22,19.54 137.46,19.3 137.62,19.3 137.91,19.59 138.22,19.59 138.53,19.28 138.53,18.98 138.1,18.54 138.1,18.41 138.35,18.16 138.5,18.16 138.93,18.6 139.26,18.6 140.28,17.57 142,17.57 143.23,16.34 143.53,16.34 143.75,16.11 143.75,16.04 143.81,15.98 144.13,15.98 v13(144.21,16.06)
  BOTTOM w0.147: U6A1.P10 144.28,16.06 v13(144.21,16.06)
M0_A_ODT: length 55
  IN1 w0.06: v11(126.05,34.79) 126.05,34.71 126.38,34.39 126.69,34.39 126.88,34.57
  IN1 w0.089: v4(146.91,26.89) 146.91,26.68 147.77,25.81 147.77,25.67 147.66,25.55 147.52,25.55 145.56,27.51 145.44,27.51 145.33,27.4 145.33,27.28 147.34,25.27 147.34,25.13 147.24,25.03 147.11,25.03 144.64,27.5 139.58,27.5 134.26,32.82 133.14,32.82 131.39,34.57 126.88,34.57
  IN3 w0.109: v13(145.79,19.36) 146.32,19.36 146.47,19.22 146.47,18.61 146.57,18.51 146.81,18.51 146.91,18.61 v4(146.91,26.89) 146.91,35.49 v13(145.79,36.61)
  BOTTOM w0.102: U7A1.J8 146.14,36.96 v13(145.79,36.61) ; U6A1.J8 146.06,19.63 v13(145.79,19.36)
M0_A_ZQ0: length 6.3
  BOTTOM w0.102: 151.92,41.87 150.84,41.87 150.62,41.64 150.32,41.64 U7A1.B3
  BOTTOM w0.117: 151.92,41.87 153.62,40.16 v4(154.76,40.16) 155,40.16 155.14,40.3 R6L1.2
M0_A_ZQ1: length 7.2
  BOTTOM w0.102: 151.84,42.53 150.84,42.53 150.57,42.25 150.57,42.04 150.36,41.84 149.73,41.84 U7A1.B4
  BOTTOM w0.117: R7A1.2 154.98,41.32 v4(154.76,41.54) 152.82,41.54 152.29,42.06 152.29,42.07 151.84,42.53
M0_B_A0: length 47.6
  IN2 w0.06: 127.88,34.73 127.2,34.73 126.68,35.25 126.13,35.8 125.95,35.8 125.85,35.69 125.85,35.54 v14(125.7,35.4)
  IN2 w0.109: v13(151.34,16.08) 153.1,16.08 153.59,16.57 153.59,19.04 153.49,19.14 153.31,19.14 153.21,19.04 153.21,17.18 153.12,17.09 152.44,17.09 152.35,17.18 152.35,24.49 152.1,24.75 147.25,24.75 146.59,25.41 146.27,25.41 145.83,25.85 140.9,25.85 134.48,32.27 133.03,32.27 131.72,33.58 129.03,33.58 127.88,34.73
  BOTTOM w0.102: U6A1.R2 151,15.73 v13(151.34,16.08)
M0_B_A1: length 46.7
  IN2 w0.109: v13(151.35,16.69) 152.06,17.4 152.06,24.37 151.99,24.44 151.76,24.44 151.68,24.37 151.68,21.85 151.61,21.78 151.38,21.78 151.3,21.85 151.3,24.04 150.95,24.39 147.75,24.39 147.62,24.26 147.62,22.75 147.53,22.66 147.3,22.66 147.21,22.75 147.21,24.37 146.48,25.1 146.2,25.1 145.74,25.56 140.78,25.56 134.36,31.98 132.92,31.98 131.57,33.33 129,33.33 127.77,34.56 127.08,34.56 v14(126.48,35.17)
  BOTTOM w0.102: v13(151.35,16.69) 151.05,16.38 U6A1.P2
M0_B_A2: length 46.4
  IN2 w0.109: v14(126.05,35.6) 126.05,35.21 126.89,34.38 127.69,34.38 128.97,33.1 131.41,33.1 132.83,31.69 134.23,31.69 140.66,25.27 145.47,25.27 145.94,24.8 146.35,24.8 146.88,24.26 146.88,17.78 146.98,17.68 147.14,17.68 147.24,17.78 147.24,22.25 147.33,22.33 147.53,22.33 147.62,22.25 147.62,18.02 147.82,17.81 150.08,17.81 150.62,17.28 150.99,17.28 150.99,17.27 v13(151.39,17.27)
  BOTTOM w0.102: U6A1.N2 151.15,17.03 v13(151.39,17.27)
M0_B_A3: length 43.5
  IN1 w0.06: 126.73,37.13 126.64,37.22 126.31,37.22 126.23,37.14 126.23,37.14 126.06,37.14 126.06,37.14 126.06,37.14 125.98,37.22 125.85,37.35 125.85,37.42 125.68,37.6 125.68,37.72 125.9,37.95 v11(125.9,38.31)
  IN1 w0.089: 126.73,37.13 126.84,37.02 127.55,37.02 128.14,37.6 130.04,37.6 130.58,37.06 130.58,36.68 133.09,34.17 136.14,34.17 140.79,29.53 147.73,29.53 148.38,28.87 148.63,28.87 149.38,28.11 149.8,28.11 151.87,26.04 151.87,22.5 151.1,21.73 151.02,21.64 151.02,20.47 150.16,19.62 150.16,18.01 150.54,17.64 150.61,17.64 150.78,17.47 150.78,16.92 v13(150.58,16.72)
  BOTTOM w0.102: U6A1.N3 150.26,17.03 v13(150.58,16.72)
M0_B_A4: length 46.6
  IN1 w0.089: v11(126.48,34.74) 126.61,34.87 131.63,34.87 133.12,33.38 134.74,33.38 135.64,32.49 135.79,32.49 136.01,32.71 136.15,32.71 136.26,32.6 136.26,32.46 136.04,32.23 136.04,32.09 136.14,31.98 136.29,31.98 136.53,32.22 136.67,32.22 136.78,32.11 136.78,31.97 136.54,31.73 136.54,31.58 136.65,31.48 136.79,31.48 137.04,31.73 137.18,31.73 137.29,31.62 137.29,31.48 137.05,31.23 137.05,31.08 139.63,28.49 146.27,28.49 147.02,27.74 147.18,27.74 147.74,27.18 147.74,26.97 148.35,26.35 151.12,26.35 151.56,25.91 151.56,22.63 150.89,21.96 150.37,21.96 150.16,21.75 150.16,20.28 149.35,19.47 149.35,18.4 149.19,18.24 148.74,18.24 148.63,18.14 148.63,17.96 148.73,17.86 149.87,17.86 150.23,17.51 150.23,16.54 150.12,16.43 149.46,16.43 149.36,16.53 149.36,17.15 149.53,17.32 v13(149.76,17.32)
  BOTTOM w0.102: U6A1.M3 150.12,17.68 v13(149.76,17.32)
M0_B_A5: length 47.3
  IN1 w0.06: v11(126.15,37.34) 126.93,37.34 127.05,37.46 127.52,37.46 127.53,37.47 127.68,37.47 128,37.8 129.58,37.8
  IN1 w0.089: v13(151.39,21.31) 151.39,20.35 151.5,20.24 151.7,20.24 151.81,20.35 151.81,21.98 151.91,22.08 152.14,22.08 152.24,21.98 152.24,20.41 152.35,20.3 152.56,20.3 152.67,20.41 152.67,22.28 152.19,22.77 152.19,26.17 151.69,26.67 151.69,26.82 151.97,27.11 151.97,27.25 151.86,27.36 151.72,27.36 151.43,27.08 151.28,27.08 151.17,27.18 151.17,27.33 151.37,27.53 151.37,27.68 151.26,27.79 151.11,27.79 150.91,27.59 150.76,27.59 150.66,27.7 150.66,27.85 150.83,28.02 150.83,28.16 150.72,28.28 150.57,28.28 150.4,28.1 150.25,28.1 149.93,28.42 149.51,28.42 149.29,28.64 149.29,29.06 148.47,29.88 140.81,29.88 136.25,34.44 133.2,34.44 130.85,36.78 130.85,37.12 130.17,37.8 129.58,37.8
  BOTTOM w0.102: U6A1.F3 150.4,21.78 150.41,21.78 150.52,21.9 151.18,21.9 151.39,21.69 v13(151.39,21.31)
M0_B_A6: length 47.2
  IN1 w0.06: v11(126.05,35.17) 126.28,34.94 126.28,34.65 126.41,34.53 126.59,34.53 126.79,34.72
  IN1 w0.089: v13(149.76,22.53) 150.02,22.27 150.76,22.27 150.96,22.47 150.96,23.17 151.25,23.46 151.25,23.65 151.14,23.76 151,23.76 150.9,23.87 150.9,24.05 151,24.16 151.14,24.16 151.25,24.27 151.25,24.44 151.14,24.55 147.92,24.55 147.82,24.65 147.82,24.85 147.92,24.95 151.05,24.95 151.15,25.05 151.15,25.23 151.05,25.33 148.34,25.33 148.24,25.43 148.24,25.59 148.34,25.69 150.92,25.69 151.02,25.79 151.02,25.94 150.92,26.04 148.22,26.04 147.42,26.84 147.42,27.05 147.05,27.42 146.89,27.42 146.34,27.98 139.77,27.98 134.64,33.1 133.14,33.1 131.52,34.72 126.79,34.72
  BOTTOM w0.102: v13(149.76,22.53) 150.05,22.23 U6A1.E3
M0_B_A7: length 47.4
  IN1 w0.06: v11(125.7,34.93) 125.56,34.79 125.56,34.54 125.68,34.43 126,34.43 126.28,34.15 126.83,34.15 126.92,34.24 127.11,34.24 127.12,34.25
  IN1 w0.089: v13(150.61,22.62) 150.16,22.62 149.9,22.88 149.48,22.88 149.35,22.75 149.35,20.25 148.58,19.48 148.58,18.56 148.13,18.11 148.13,17.47 147.84,17.17 147.41,17.17 147.34,17.1 147.34,14.57 147.24,14.47 147.05,14.47 146.93,14.59 146.93,24.04 144.2,26.77 139.28,26.77 133.79,32.25 133.19,32.25 131.19,34.25 127.12,34.25
  BOTTOM w0.102: U6A1.E2 v13(150.61,22.62)
M0_B_A8: length 48.3
  TOP w0.06: v11(125.76,34.63) 125.72,34.67 U3.BN58
  IN1 w0.06: 126.94,34.43 126.78,34.27 126.33,34.27 126.02,34.58 125.81,34.58 v11(125.76,34.63)
  IN1 w0.089: v13(150.53,23.22) 150.52,23.2 150.27,23.2 150.16,23.31 150.16,24.13 150.05,24.24 149.23,24.24 149.14,24.15 149.14,23.71 149.04,23.61 148.82,23.61 148.71,23.71 148.71,24.1 148.57,24.24 147.77,24.24 147.67,24.14 147.67,21.03 147.81,20.89 148.43,20.89 148.53,20.79 148.53,20.64 148.43,20.53 147.76,20.53 147.66,20.43 147.66,20.28 147.76,20.18 148.37,20.18 148.46,20.09 148.46,19.9 148.37,19.81 147.75,19.81 147.67,19.74 147.67,17.58 147.57,17.48 147.34,17.48 147.24,17.58 147.24,24.17 144.38,27.03 139.39,27.03 133.92,32.49 133.22,32.49 131.29,34.43 126.94,34.43
  BOTTOM w0.102: v13(150.53,23.22) 150.75,23 150.77,23 150.89,22.88 U6A1.D2
M0_B_A9: length 43
  IN1 w0.06: v11(126.39,38.31) 126.56,38.47 128.16,38.47
  IN1 w0.089: v4(153.46,24.12) 154.08,24.12 154.25,24.29 154.25,27.08 154.15,27.19 153.97,27.19 153.87,27.08 153.87,25.31 153.76,25.2 153.57,25.2 153.46,25.31 153.46,27.52 149.32,31.66 141.28,31.66 139.77,33.16 136.84,36.1 134.56,36.1 134,36.66 132.94,36.66 131.13,38.47 128.16,38.47
  BOTTOM w0.102: U6A1.C2 151.27,23.81 152.33,23.81
  BOTTOM w0.147: v4(153.46,24.12) 153.14,23.8 152.34,23.8 152.33,23.81
M0_B_ZQ0: length 7
  BOTTOM w0.102: 151.52,25.24 151.43,25.15 151.43,24.77 151.19,24.54 150.84,24.54 150.62,24.31 150.32,24.31 U6A1.B3
  BOTTOM w0.117: R6L3.2 154.98,27.93 154.97,27.92 154.2,27.92 v4(154.02,27.74) 151.52,25.24
M0_B_ZQ1: length 8.1
  BOTTOM w0.102: U6A1.B4 149.73,24.51 150.36,24.51 150.57,24.72 150.57,24.92 150.89,25.24
  BOTTOM w0.117: 150.89,25.24 154.59,28.95 v4(154.64,28.95) R6L2.2
M0_CKE0: length 58.7
  IN2 w0.06: v14(125.16,37.34) 125.54,37.34 125.66,37.46 128.02,37.46 128.34,37.14 128.34,37.01
  IN2 w0.109: v4(148.54,29.24) 150.08,29.24 150.16,29.32 150.16,29.62 150.08,29.7 148.36,29.7 148.08,29.42 148.08,28.96 147.98,28.87 147.73,28.87 147.51,29.09 141.67,29.09 135.47,35.29 132.99,35.29 132.63,35.64 129.7,35.64 128.34,37.01
  IN3 w0.109: v13(150.55,18.63) 150.44,18.63 149.89,18.08 148.92,18.08 148.54,18.45 148.54,22.37 148.55,22.38 148.55,23.41 148.54,23.42 v4(148.54,29.24) 148.06,29.24 147.95,29.14 147.95,27.79 147.85,27.69 147.61,27.69 147.51,27.79 147.51,30.78 148.54,31.81 148.54,35.56 149.32,36.35 150.14,36.35 150.15,36.35 150.32,36.35 v13(150.61,36.06)
  BOTTOM w0.102: U7A1.K3 150.36,36.31 150.61,36.07 v13(150.61,36.06) ; U6A1.K3 150.55,18.63 v13(150.55,18.63)
M0_CKE1: length 56.1
  IN2 w0.06: v14(125.41,37.02) 125.73,37.34 127.97,37.34 128.19,37.12 128.19,36.91
  IN2 w0.109: 128.19,36.91 128.45,36.65 128.45,36.52 128.39,36.46 128.39,36.36 128.53,36.22 128.63,36.22 128.69,36.28 128.82,36.28 128.94,36.16 128.94,36.04 128.87,35.97 128.87,35.89 129.03,35.73 129.11,35.73 129.18,35.8 129.3,35.8 129.42,35.68 129.42,35.55 129.36,35.49 129.36,35.38 129.49,35.25 129.6,35.25 129.75,35.39 129.99,35.39 130.08,35.3 130.08,35.13 130.17,35.04 130.33,35.04 130.42,35.13 130.42,35.3 130.5,35.37 130.69,35.37 130.76,35.3 130.76,35.13 130.84,35.06 131.03,35.06 131.11,35.13 131.11,35.28 131.18,35.36 131.37,35.36 131.45,35.28 131.45,35.15 131.53,35.08 131.72,35.08 131.79,35.15 131.79,35.3 131.88,35.39 132.5,35.39 133.04,34.86 135.48,34.86 141.55,28.8 141.91,28.8 141.99,28.71 141.99,28.53 142.08,28.44 142.25,28.44 142.34,28.53 142.34,28.71 142.43,28.8 142.59,28.8 142.68,28.71 142.68,28.53 142.77,28.44 142.93,28.44 143.02,28.53 143.02,28.71 143.11,28.8 143.28,28.8 143.37,28.71 143.37,28.53 143.45,28.44 143.62,28.44 143.71,28.53 143.71,28.71 143.8,28.8 143.96,28.8 144.05,28.71 144.05,28.53 144.14,28.44 144.31,28.44 144.39,28.53 144.39,28.71 144.48,28.8 144.65,28.8 144.74,28.71 144.74,28.53 144.83,28.44 144.99,28.44 145.08,28.53 145.08,28.71 145.17,28.8 145.33,28.8 145.42,28.71 145.42,28.53 145.51,28.44 145.68,28.44 145.77,28.53 145.77,28.71 145.86,28.8 146.02,28.8 146.11,28.71 146.11,28.53 146.2,28.44 146.36,28.44 146.45,28.53 146.45,28.71 146.54,28.8 146.71,28.8 146.79,28.71 146.79,28.53 146.88,28.44 147.05,28.44 147.14,28.53 147.14,28.71 147.23,28.8 147.39,28.8 147.48,28.71 147.48,28.53 147.57,28.44 148.42,28.44 148.64,28.65 148.84,28.65 148.9,28.72 148.9,28.86 148.99,28.95 149.13,28.95 149.22,28.86 149.22,28.73 149.3,28.65 149.52,28.65 v4(149.67,28.8)
  IN3 w0.109: v13(149.79,35.96) 150.18,35.57 150.18,34.2 150.17,34.19 150.17,31.62 150.42,31.36 150.42,31.21 150.28,31.07 149.75,31.07 149.65,30.96 149.65,30.73 149.75,30.62 150.59,30.62 150.69,30.52 150.69,30.28 150.59,30.18 149.8,30.18 149.67,30.05 v4(149.67,28.8) 149.67,24.91 150.17,24.41 150.17,23.07 150.18,23.06 150.18,19.73 v13(149.76,19.31)
  BOTTOM w0.102: U7A1.K4 149.4,36.29 149.73,35.96 v13(149.79,35.96) ; v13(149.76,19.31) 149.43,18.98 U6A1.K4
M0_CS0_N: length 52.6
  IN1 w0.06: 127.98,38.32 126.98,38.32 v11(126.64,37.98)
  IN1 w0.089: v4(150.59,29.6) 149.04,31.14 141.13,31.14 136.65,35.62 133.65,35.62 130.94,38.32 127.98,38.32
  IN3 w0.109: v13(150.59,35.35) 150.98,34.96 150.98,31.12 151.17,30.92 152.57,30.92 152.67,30.82 152.67,30.58 152.57,30.48 151.35,30.48 151.25,30.38 151.25,30.14 151.35,30.04 152.47,30.04 152.57,29.94 152.57,29.7 152.47,29.6 v4(150.59,29.6) 150.59,24.99 150.98,24.61 150.98,19.16 150.98,19.16 150.98,18.31 v13(150.67,18)
  BOTTOM w0.102: U6A1.L3 150.21,18.33 150.54,18 v13(150.67,18) ; v13(150.59,35.35) 150.51,35.35 U7A1.L3
M0_CS1_N: length 52.3
  IN1 w0.06: v11(125.33,35.57) 125.59,35.57 125.64,35.61 125.73,35.61 125.85,35.73 125.85,35.74 125.91,35.8 126.56,35.8 126.68,35.68 126.68,35.55 126.77,35.47 127.22,35.47 127.3,35.54
  IN1 w0.089: v4(149.09,27.59) 149.09,27.44 149.24,27.28 149.88,27.28 150.03,27.13 150.03,26.97 149.93,26.87 148.66,26.87 148.55,26.98 148.55,28.18 148.45,28.28 148.32,28.28 148.22,28.18 148.22,27.79 148.13,27.69 147.99,27.69 147.89,27.79 147.89,28.63 147.72,28.8 147.61,28.8 147.49,28.68 147.49,28.35 147.39,28.25 147.24,28.25 147.14,28.35 147.14,28.9 147.03,29.01 140.64,29.01 136.01,33.64 133.09,33.64 131.71,35.02 127.97,35.02 127.45,35.54 127.3,35.54
  IN3 w0.109: v13(149.78,35.38) 149.37,34.96 149.37,31.85 148.94,31.43 148.94,30.84 149.09,30.69 149.09,30.54 148.94,30.4 148.56,30.4 148.46,30.29 148.46,30.06 148.56,29.95 148.96,29.95 149.09,29.83 v4(149.09,27.59) 149.09,24.58 149.36,24.31 149.36,19.08 v13(149.77,18.67)
  BOTTOM w0.102: v13(149.78,35.38) 149.49,35.66 U7A1.L4 ; v13(149.77,18.67) 149.43,18.33 U6A1.L4
