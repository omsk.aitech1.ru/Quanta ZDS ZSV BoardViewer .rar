# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.813x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-MPL73-1R5
  rect 1.676x3.404 smd: 1(-2.843,0) 2(2.843,0)
CHOKE-PCMB041B-1R0MS
  rect 1.499x2.489 smd: 1(-1.85,0) 2(1.85,0)
CHOKE-PCMB053T-1R0MS
  rect 2.007x2.489 smd: 1(-2.5,0) 2(2.5,0)
D-1X0_6-D24V0L1B2LPS
  rect 0.457x0.61 smd: 1(-0.375,0) 2(0.375,0)
D-5_8X4_3-3P
  rect 1.346x1.499 smd: 1(2.73,1.065) 2(2.73,-1.065)
  rect 4.851x3.607 smd: 3(-0.97,0)
D-DO-214AC
  rect 1.88x2.032 smd: 1(-2.1,0) 2(2.1,0)
D-SOD523-1_2X0_8-1N4148WT-7
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
DFN8-2X2-5-9P-NCP5901
  rect 0.305x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.295x0.889 smd: 9(0,0)
DFN2018-6-1_8125X2_0125-5-7P
  rect 0.356x0.254 smd: 1(0.975,-0.5) 2(0.975,0) 3(0.975,0.5) 4(-0.975,0.5) 5(-0.975,0) 6(-0.975,-0.5)
  rect 1.194x1.6 smd: 7(0,0)
DHVQFN20-4_5X2_5-5-21P
  rect 0.991x0.305 smd: 1(-2.35,-0.25) 10(2.35,-0.25) 11(2.35,0.25) 20(-2.35,0.25)
  rect 0.305x0.991 smd: 2(-1.75,-1.35) 3(-1.25,-1.35) 4(-0.75,-1.35) 5(-0.25,-1.35) 6(0.25,-1.35) 7(0.75,-1.35) 8(1.25,-1.35) 9(1.75,-1.35) 12(1.75,1.35) 13(1.25,1.35) 14(0.75,1.35) 15(0.25,1.35) 16(-0.25,1.35) 17(-0.75,1.35) 18(-1.25,1.35) 19(-1.75,1.35)
  rect 2.997x0.991 smd: 21(0,0)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
ESD-3_8X1-9P
  rect 0.203x0.61 smd: 1(-1.7,-0.475) 2(-0.8,-0.475) 3(0,-0.475) 4(0.8,-0.475) 5(1.7,-0.475) 6(1.3,0.475) 7(0.4,0.475) 8(-0.4,0.475) 9(-1.3,0.475)
ESD-69X31
  custom 0.2x0.2 smd: 1(-0.476,0) 2(0.476,0)
F3_2X1_65-2_8
  rect 0.991x1.803 smd: 1(-1.4,0) 2(1.4,0)
FUNTP-C50-79-2P
  round 1.27 smd: 1(-1,0) 2(1,0)
H-C51D51N
  round 1.295 hole 1.295 unplated: (0,0)
H-C79D79N
  round 2.007 hole 2.007 unplated: (0,0)
H-C197D98P2BB
  round 5.004 hole 2.489: 1(0,0)
H-O79X118D79X118N
  oval 2.007x2.997 hole 2.007x2.997 unplated: (0,0)
H-T99I-1
  round 5.512 hole 2.794: 1(0,0)
H-T99I-2BB
  round 5.004 hole 2.794: 1(0,0)
H-TC217IBC197D98P2BB
  round 5.512 hole 2.489: 1(0,0)
H-TC256BC177D177P2
  round 6.502 hole 4.496: 1(0,0)
H-TC276BC236D197P2
  round 7.01 hole 5.004: 1(0,0)
H-TC315BC236D197P2
  round 8.001 hole 5.004: 1(0,0)
L3_2X2_5-1_55
  rect 1.245x2.007 smd: 1(-1.275,0) 2(1.275,0)
L4_2X4_2
  rect 1.499x2.489 smd: 1(-1.85,0) 2(1.85,0)
L6_6X6_47-1_3
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
LEDLTST-C190TGKT
  rect 0.787x0.787 smd: 1(-0.75,0) 2(0.75,0)
LEDLTST-S326KGJRKT-3P-SMT
  rect 0.991x0.991 smd: 1(-1.5,0) 3(1.5,0)
  rect 0.889x0.889 smd: 2(0,-0.65)
LGA16-3X3-5
  rect 0.305x0.94 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 9(1,1.525) 10(0.5,1.525) 11(0,1.525) 12(-0.5,1.525) 13(-1,1.525)
  rect 0.94x0.305 smd: 6(1.525,-0.5) 7(1.525,0) 8(1.525,0.5) 14(-1.525,0.5) 15(-1.525,0) 16(-1.525,-0.5)
NGFF-80149-3521-75P-KB
  round 1.092 hole 1.092 unplated: (-11,0)
  round 1.6 hole 1.6 unplated: (11,0)
  round 0.762 hole 0.508: 1(9.25,-0.09) 3(8.75,-0.89) 5(8.25,-0.09) 7(7.75,-0.89) 9(7.25,-0.09) 11(6.75,-0.89) 21(4.25,-0.09) 23(3.75,-0.89) 25(3.25,-0.09) 27(2.75,-0.89) 29(2.25,-0.09) 31(1.75,-0.89) 33(1.25,-0.09) 35(0.75,-0.89) 37(0.25,-0.09) 39(-0.25,-0.89) 41(-0.75,-0.09) 43(-1.25,-0.89) 45(-1.75,-0.09) 47(-2.25,-0.89) 49(-2.75,-0.09) 51(-3.25,-0.89) 53(-3.75,-0.09) 55(-4.25,-0.89) 57(-4.75,-0.09) 59(-5.25,-0.89) 61(-5.75,-0.09) 63(-6.25,-0.89) 65(-6.75,-0.09) 67(-7.25,-0.89) 69(-7.75,-0.09) 71(-8.25,-0.89) 73(-8.75,-0.09) 75(-9.25,-0.89)
  rect 0.305x1.499 smd: 2(9,1.7) 4(8.5,1.7) 6(8,1.7) 8(7.5,1.7) 10(7,1.7) 20(4.5,1.7) 22(4,1.7) 24(3.5,1.7) 26(3,1.7) 28(2.5,1.7) 30(2,1.7) 32(1.5,1.7) 34(1,1.7) 36(0.5,1.7) 38(0,1.7) 40(-0.5,1.7) 42(-1,1.7) 44(-1.5,1.7) 46(-2,1.7) 48(-2.5,1.7) 50(-3,1.7) 52(-3.5,1.7) 54(-4,1.7) 56(-4.5,1.7) 58(-5,1.7) 60(-5.5,1.7) 62(-6,1.7) 64(-6.5,1.7) 66(-7,1.7) 68(-7.5,1.7) 70(-8,1.7) 72(-8.5,1.7) 74(-9,1.7)
  oval 0.711x1.956 hole 0.508x1.753: 76(11.25,-4.05) 77(-11.25,-4.05)
NGFF-NASE0-A6701-1S14-75P-KE
  round 1.092 hole 1.092 unplated: (-11,0)
  round 1.6 hole 1.6 unplated: (11,0)
  round 0.762 hole 0.508: 1(9.25,-0.09) 3(8.75,-0.89) 5(8.25,-0.09) 7(7.75,-0.89) 9(7.25,-0.09) 11(6.75,-0.89) 13(6.25,-0.09) 15(5.75,-0.89) 17(5.25,-0.09) 19(4.75,-0.89) 21(4.25,-0.09) 23(3.75,-0.89) 33(1.25,-0.09) 35(0.75,-0.89) 37(0.25,-0.09) 39(-0.25,-0.89) 41(-0.75,-0.09) 43(-1.25,-0.89) 45(-1.75,-0.09) 47(-2.25,-0.89) 49(-2.75,-0.09) 51(-3.25,-0.89) 53(-3.75,-0.09) 55(-4.25,-0.89) 57(-4.75,-0.09) 59(-5.25,-0.89) 61(-5.75,-0.09) 63(-6.25,-0.89) 65(-6.75,-0.09) 67(-7.25,-0.89) 69(-7.75,-0.09) 71(-8.25,-0.89) 73(-8.75,-0.09) 75(-9.25,-0.89)
  rect 0.305x1.499 smd: 2(9,1.7) 4(8.5,1.7) 6(8,1.7) 8(7.5,1.7) 10(7,1.7) 12(6.5,1.7) 14(6,1.7) 16(5.5,1.7) 18(5,1.7) 20(4.5,1.7) 22(4,1.7) 32(1.5,1.7) 34(1,1.7) 36(0.5,1.7) 38(0,1.7) 40(-0.5,1.7) 42(-1,1.7) 44(-1.5,1.7) 46(-2,1.7) 48(-2.5,1.7) 50(-3,1.7) 52(-3.5,1.7) 54(-4,1.7) 56(-4.5,1.7) 58(-5,1.7) 60(-5.5,1.7) 62(-6,1.7) 64(-6.5,1.7) 66(-7,1.7) 68(-7.5,1.7) 70(-8,1.7) 72(-8.5,1.7) 74(-9,1.7)
  oval 0.711x1.956 hole 0.508x1.753: 76(11.25,-4.05) 77(-11.25,-4.05)
PG-TSDSON-8-8P-R
  rect 0.787x0.33 smd: 1(1.5,-0.975) 2(1.5,-0.325) 3(1.5,0.325) 4(1.5,0.975)
  custom 0.573x0.573 smd: 5(-0.72,0)
  rect 0.66x0.33 smd: 6(-1.575,0.325) 7(-1.575,-0.325) 8(-1.575,-0.975)
POWER-3X3-65-10P
  rect 0.457x0.457 smd: 1(-0.975,-1.38) 2(-0.325,-1.38) 3(0.325,-1.38) 4(0.975,-1.38) 5(0.975,1.38) 6(0.325,1.38) 7(-0.325,1.38) 8(-0.975,1.38)
  rect 2.54x0.559 smd: 9(0,-0.672)
  rect 2.54x1.041 smd: 10(0,0.433)
POWER-5X6-1_27-7P
  rect 0.635x0.66 smd: 1(2.835,-1.905) 5(-2.835,1.905) 6(-2.835,0.635) 7(-2.835,-0.635) 8(-2.835,-1.905)
  custom 0.485x0.485 smd: 2(2.18,0.115)
  rect 2.159x3.988 smd: 9(-0.525,0)
QFN10-3X3-5-16P
  rect 0.279x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.413x0.413 smd: 11(0,0)
  round 0.508 hole 0.254: 12(-0.75,0.5) 13(0.75,0.5) 14(-0.75,-0.5) 15(0.75,-0.5) 16(0,0)
QFN12-1_25X2_1-4
  rect 0.203x0.889 smd: 1(-0.8,-0.775) 2(-0.4,-0.775) 3(0,-0.775) 4(0.4,-0.775) 5(0.8,-0.775) 7(0.8,0.775) 8(0.4,0.775) 9(0,0.775) 10(-0.4,0.775) 11(-0.8,0.775)
  rect 1.194x0.254 smd: 6(1.05,0) 12(-1.05,0)
QFN13-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.254x0.711 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN40-6X4-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-1.4,-2.975) 2(-1,-2.975) 3(-0.6,-2.975) 4(-0.2,-2.975) 5(0.2,-2.975) 6(0.6,-2.975) 7(1,-2.975) 8(1.4,-2.975) 9(1.975,-2.2) 10(1.975,-1.8) 11(1.975,-1.4) 12(1.975,-1) 13(1.975,-0.6) 14(1.975,-0.2) 15(1.975,0.2) 16(1.975,0.6) 17(1.975,1) 18(1.975,1.4) 19(1.975,1.8) 20(1.975,2.2) 21(1.4,2.975) 22(1,2.975) 23(0.6,2.975) 24(0.2,2.975) 25(-0.2,2.975) 26(-0.6,2.975) 27(-1,2.975) 28(-1.4,2.975) 29(-1.975,2.2) 30(-1.975,1.8) 31(-1.975,1.4) 32(-1.975,1) 33(-1.975,0.6) 34(-1.975,0.2) 35(-1.975,-0.2) 36(-1.975,-0.6) 37(-1.975,-1) 38(-1.975,-1.4) 39(-1.975,-1.8) 40(-1.975,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
QFN40-6X6-5-41P-0_6H
  rect 0.305x0.991 smd: 1(-2.25,-3.1) 2(-1.75,-3.1) 3(-1.25,-3.1) 4(-0.75,-3.1) 5(-0.25,-3.1) 6(0.25,-3.1) 7(0.75,-3.1) 8(1.25,-3.1) 9(1.75,-3.1) 10(2.25,-3.1) 21(2.25,3.1) 22(1.75,3.1) 23(1.25,3.1) 24(0.75,3.1) 25(0.25,3.1) 26(-0.25,3.1) 27(-0.75,3.1) 28(-1.25,3.1) 29(-1.75,3.1) 30(-2.25,3.1)
  rect 0.991x0.305 smd: 11(3.1,-2.25) 12(3.1,-1.75) 13(3.1,-1.25) 14(3.1,-0.75) 15(3.1,-0.25) 16(3.1,0.25) 17(3.1,0.75) 18(3.1,1.25) 19(3.1,1.75) 20(3.1,2.25) 31(-3.1,2.25) 32(-3.1,1.75) 33(-3.1,1.25) 34(-3.1,0.75) 35(-3.1,0.25) 36(-3.1,-0.25) 37(-3.1,-0.75) 38(-3.1,-1.25) 39(-3.1,-1.75) 40(-3.1,-2.25)
  rect 4.597x4.597 smd: 41(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN52-6X6-4-53P-1H
  custom 0.05x0.05 smd: 1(-2.4,-2.885) 13(2.4,-2.885) 14(2.885,-2.4) 26(2.885,2.4) 27(2.4,2.885) 39(-2.4,2.885) 40(-2.885,2.4) 52(-2.885,-2.4)
  rect 0.203x0.635 smd: 2(-2,-2.885) 3(-1.6,-2.885) 4(-1.2,-2.885) 5(-0.8,-2.885) 6(-0.4,-2.885) 7(0,-2.885) 8(0.4,-2.885) 9(0.8,-2.885) 10(1.2,-2.885) 11(1.6,-2.885) 12(2,-2.885) 28(2,2.885) 29(1.6,2.885) 30(1.2,2.885) 31(0.8,2.885) 32(0.4,2.885) 33(0,2.885) 34(-0.4,2.885) 35(-0.8,2.885) 36(-1.2,2.885) 37(-1.6,2.885) 38(-2,2.885)
  rect 0.635x0.203 smd: 15(2.885,-2) 16(2.885,-1.6) 17(2.885,-1.2) 18(2.885,-0.8) 19(2.885,-0.4) 20(2.885,0) 21(2.885,0.4) 22(2.885,0.8) 23(2.885,1.2) 24(2.885,1.6) 25(2.885,2) 41(-2.885,2) 42(-2.885,1.6) 43(-2.885,1.2) 44(-2.885,0.8) 45(-2.885,0.4) 46(-2.885,0) 47(-2.885,-0.4) 48(-2.885,-0.8) 49(-2.885,-1.2) 50(-2.885,-1.6) 51(-2.885,-2)
  rect 4.75x4.75 smd: 53(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.813x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SOIC8-8-1_27
  rect 0.533x1.6 smd: 1(-1.905,-3.8) 2(-0.635,-3.8) 3(0.635,-3.8) 4(1.905,-3.8) 5(1.905,3.8) 6(0.635,3.8) 7(-0.635,3.8) 8(-1.905,3.8)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-1_3H
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23_123-2_8-1_9
  rect 1.092x0.533 smd: 1(1.45,-0.95) 2(1.45,0.95) 3(-1.45,0)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SPAD-C138
  round 3.505 smd: 1(0,0)
SPAD-RE173X114NP
  rect 4.394x2.896 smd: 1(0,0)
SPAD-RE197X197NP
  rect 5.004x5.004 smd: 1(0,0)
SPAD-RE236X118NP
  rect 5.994x2.997 smd: 1(0,0)
SPAD-RE275X126NP
  rect 6.985x3.2 smd: 1(0,0)
SPAD-RE275X275NP
  rect 6.985x6.985 smd: 1(0,0)
SPAD-ZDS-1
  rect 7.01x6.502 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SW-BTE-P-V-TR-4P
  round 0.889 hole 0.889 unplated: (-0.85,0)
  round 0.711 hole 0.711 unplated: (0.85,0)
  rect 0.889x0.762 smd: 1(0.95,1.425) 2(0.95,-1.425) 3(-0.95,1.425) 4(-0.95,-1.425)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
TDFN10-3X3-5-11P-APL5620QBI-TRG
  rect 0.305x0.991 smd: 1(-1,-1.6) 2(-0.5,-1.6) 3(0,-1.6) 4(0.5,-1.6) 5(1,-1.6) 6(1,1.6) 7(0.5,1.6) 8(0,1.6) 9(-0.5,1.6) 10(-1,1.6)
  rect 2.438x1.575 smd: 11(0,0)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TQFN10-1_6X1_3-4-SMT
  rect 0.203x0.711 smd: 1(-0.2,-0.46) 2(0.2,-0.46) 6(0.2,0.46) 7(-0.2,0.46)
  rect 0.61x0.203 smd: 3(0.785,-0.4) 4(0.785,0) 5(0.785,0.4) 8(-0.785,0.4) 9(-0.785,0) 10(-0.785,-0.4)
TSSOP10-4_9-5
  rect 0.279x1.499 smd: 1(-1,-2.3) 2(-0.5,-2.3) 3(0,-2.3) 4(0.5,-2.3) 5(1,-2.3) 6(1,2.3) 7(0.5,2.3) 8(0,2.3) 9(-0.5,2.3) 10(-1,2.3)
UB31-DX07B024XJ1AR1000-24P-SMT
  round 0.787 hole 0.787 unplated: (-3.6,0)
  oval 0.94x0.787 hole 0.94x0.787 unplated: (3.6,0)
  oval 1.092x1.956 hole 0.61x1.448: 1(-4.8,-0.875) 2(4.8,-0.875)
  oval 1.092x2.388 hole 0.61x1.6: 3(-5.8,-5.1) 4(5.8,-5.1)
  rect 0.305x1.092 smd: A1(-2.75,0.66) A2(-2.25,0.66) A3(-1.75,0.66) A4(-1.25,0.66) A5(-0.75,0.66) A6(-0.25,0.66) A7(0.25,0.66) A8(0.75,0.66) A9(1.25,0.66) A10(1.75,0.66) A11(2.25,0.66) A12(2.75,0.66)
  round 0.61 hole 0.406: B1(2.8,-0.55) B2(2.4,-1.35) B3(1.6,-1.35) B4(1.35,-0.55) B5(0.8,-1.35) B6(0.4,-0.55) B7(-0.4,-0.55) B8(-0.8,-1.35) B9(-1.35,-0.55) B10(-1.6,-1.35) B11(-2.4,-1.35) B12(-2.8,-0.55)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
WDFN5-3_05X3_05-65
  rect 0.66x0.432 smd: 1(1.385,-0.975) 2(1.385,-0.325) 3(1.385,0.325) 4(1.385,0.975)
  custom 0.575x0.575 smd: 5(-0.735,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
+1.5V: C444.2 L11.2 PC212.1 PR305.2 PU15.2 PU15.3 R219.2 R374.2
+1.5VA: C440.1 C445.1 L11.1 U19.40
+3.3V_TYPEC_MUX: C280.1 C285.1 C286.1 C287.1 C344.1 C345.1 Q18.2 Q18.5 R241.2 R266.1 R269.2 R273.1 R284.1 R285.1 R295.2 R298.1 R303.2 R304.2 R318.2 R334.2 R366.2 R10950.1 U13.6 U13.20 U13.28
+3V: C21.2 C22.1 C23.2 C25.2 C26.2 C30.2 C31.1 C58.2 C67.1 C262.2 C352.1 C385.1 CN2.2 CN2.4 CN2.70 CN2.72 CN2.74 CN7.2 CN9.17 CN10.1 PC155.2 PR12.1 PR131.2 PR140.2 PR150.2 PR219.1 PR303.1 PR526.1 PU19.5 Q8.2 Q34.2 R27.1 R28.1 R32.2 R45.1 R60.2 R66.2 R78.2 R83.1 R88.1 R94.2 R97.1 R100.2 R110.1 R113.2 R114.1 R119.1 R171.1 R220.2 R226.2 R231.2 R253.1 R276.2 R284.2 R329.2 R355.1 R379.2 R381.2 R395.1 R478.2 R481.2 R484.1 R485.1 R10931.2 U5.1 U5.8 U5.14
+3V_EC_VCC: C455.1 R485.2 U17.J5
+3V_LCDVCC: PC137.1 PR179.2 PU9.8 PU9.9
+3V_PANEL: PC129.1 PR179.1 R410.1
+3V_PANEL_CONN: C386.1 C387.2 CN9.12 CN9.13 CN9.14 R410.2
+3V_POA_R: C731.2 CN17.1 Q6062.3 R1530.1
+3V_RTC: BAT1.8 C14.1 C44.2 C211.1 D3.1 D39.1 R89.1 R95.1 R141.1 R196.1 R251.1 U3.AR19 U3.AT19
+3V_S2: PC166.1 PR219.2 PU13.13 PU13.14
+3V_SPI: C1.1 R3.2 R4.2 R9.1 R13.1 R145.2 R325.2 U1.8
+3V_TP_CLICK: C446.1 CN12.1 CN16.8 Q48.2 Q48.5 Q6063.3 Q6066.2 Q6066.5 R444.2 R450.2 R481.1 R514.1 R543.1 R675.2 R676.2
+3V_TS: C55.1 C60.2 CN6.7 CN6.8 R171.2
+3V_WLAN: PC24.1 PR8.1 PU3.13 PU3.14
+3VPCU_HW_SD: PC46.1 PR24.1 PU4.5
+4.6V_PD_C1: PC233.1 PC244.1 PQ27.3 PR325.2 PR521.2 PU17.5
+4.6V_PD_C2: PC241.1 PQ24.3 PR507.2 PR509.2 PU21.5
+5V: C429.1 C457.2 C466.1 L13.1 PC193.2 PR271.2 Q28.3 R417.2 R433.2 U21.1 U21.3
+5V_PVDD: C384.1 C415.1 C431.1 C438.1 L12.2 U19.41 U19.46
+5V_S2: PC181.1 PR271.1 PU13.8 PU13.9
+5V_USBP0_L: C931.2 Q19.1 Q19.2 Q19.3 U10.6 U10.7 U10.8
+5V_USBP1_L: C954.2 Q6070.1 Q6070.2 Q6070.3 U43.6 U43.7 U43.8
+5VA: C459.1 C461.1 C462.1 C468.2 L13.2 R492.1 U19.26 U21.4
+5VS5_PD: PD10.1 PD12.1 PQ23.4 PQ26.4 PR25.2 PR522.2 R10998.1
+V3.3S_SEN: C377.1 C378.1 C379.1 C383.1 C414.1 C467.1 D21.1 L14.2 Q10.2 Q10.5 Q11.2 Q11.5 Q27.2 Q33.2 Q33.5 R169.2 R174.2 R177.2 R186.2 R390.2 R411.1 R412.1 R413.2 R420.2 R421.2 R456.2 R461.1 R473.1 R484.2 R488.2 R500.2 U20.D4 U20.D6 U20.E4 U20.E6 U20.F4 U20.F8
+VCC_PRIM_SRC: PC79.2 PC125.1 PC130.1 PL13.2 PR57.2 PR176.1
+VCC_VCCIO_SRC: PC66.1 PC67.1 PC116.2 PL8.2 PR51.1 PR166.2
+VCCAPLL_1P0: C90.2 C91.2 EC8.2 EL1.2 U3.AA18 U3.AA19
+VCCDSW_1P0: C178.1 C183.1 C195.2 U3.AL2 U3.AM1
+VCCIO_S2: PC134.1 PR178.1 PU9.13 PU9.14
+VCCPAZIO: C226.2 C257.2 R211.1 R219.1 R220.1 U3.AT23 U3.AV22
+VCCPDSW_3P3: C198.2 R104.1 R115.1 U3.AL15 U3.AM13
+VCCPSPI: C224.2 R145.1 R149.1 R504.1 U3.AT15 U3.AV15
+VCCSFR: C69.2 PC45.1 PC56.1 PR23.1 PR46.2 U3.R27 U3.T27
+VCCST_CPU: C106.2 PC61.1 PC206.2 PR46.1 PR257.2 PR267.1 PR268.1 PR272.1 PU6.13 PU6.14 Q1.3 R2.2 R156.1 R163.1 R166.2 R167.1 R187.1 U3.V26 U3.Y26
+VCCST_S2: PC36.1 PR23.2 PU3.8 PU3.9
+VCCSTG: C88.2 C125.1 PC127.1 PR178.2 R161.1 U3.AA26 U3.AC26 U3.R26 U3.T26
+VDDD_SUPPLY: C950.1 C951.2 C952.2 R10978.1 R10979.1 R10980.1 R10981.1 R10990.2 R10994.1 R10997.1 R10998.2 TP6.1 U40.31 U40.32
+VIN: PC48.1 PC57.2 PC81.2 PC208.1 PC216.1 PC219.1 PC222.2 PC224.1 PC225.1 PC226.1 PL4.1 PL11.1 PL12.1 PQ10.2 PQ10.3 PQ10.4 PQ10.9 PQ12.5 PR6.2 PR9.2 PR27.2 PR52.2 PR108.2 PR171.2 PR246.2 PR260.2 PR262.2 PU5.E5 PU5.M8 PU5.N6 R350.1 R380.1
+VIN_PANEL: C360.2 C369.1 CN9.30 CN9.31 CN9.32 R350.2
+VIN_VCC_CORE: PC71.1 PC77.1 PC121.1 PL12.2 PQ6.2 PR194.2
+VIN_VCCGT: PC72.1 PC78.1 PC120.1 PL11.2 PQ7.2
+VIN_VCCSA: PC37.1 PC40.2 PC44.1 PL4.2 PQ2.2 PQ2.3 PQ2.4 PQ2.9
AVCC_3.3VA: C453.1 C454.1 L14.1 U20.D5
DVDD_IO: C365.1 C374.1 R374.1 R379.1 U19.9
GND: BAT1.9 BAT1.10 BAT1.11 BAT1.12 C1.2 C3.2 C4A1.1 C4A2.1 C4A3.1 C4A4.1 C4A5.1 C5.2 C5L1.2 C5L2.2 C5L3.2 C5L4.2 C5L5.2 C6.2 C6A1.2 C6A2.2 C6A3.2 C6A4.2 C6A5.2 C6A6.1 C6A7.2 C6A8.2 C6A9.2 C6L1.2 C6L2.2 C6L3.2 C6L4.2 C6L5.2 C6L6.2 C6L7.2 C6L8.2 C6L9.1 C7.2 C7A1.2 C7A2.1 C7L1.1 C7L2.2 C7L3.1 C7L4.1 C7L5.1 C7L6.2 C7L7.1 C7L8.1 C7L9.2 C7L10.1 C7L11.1 C7L12.1 C7L13.2 C7L14.1 C7L15.1 C7L16.1 C9.2 C10.2 C11.2 C12.2 C13.1 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.1 C22.2 C23.1 C24.2 C25.1 C26.1 C27.2 C28.2 C29.2 C30.1 C31.2 C32.2 C41.2 C42.2 C43.2 C44.1 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C57.2 C58.1 C59.1 C60.1 C61.2 C62.1 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.1 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.1 C85.1 C86.2 C87.2 C88.1 C89.1 C90.1 C91.1 C92.2 C93.2 C94.2 C95.1 C96.2 C97.2 C98.2 C99.2 C100.2 C101.1 C102.2 C103.1 C104.1 C105.1 C106.1 C107.1 C108.1 C110.2 C111.2 C112.1 C113.2 C115.2 C116.1 C117.2 C118.2 C119.2 C120.1 C121.2 C122.2 C123.1 C124.2 C125.2 C127.2 C128.2 C129.1 C130.2 C131.1 C132.1 C133.2 C135.1 C136.2 C137.2 C138.2 C139.2 C140.2 C141.1 C142.1 C143.1 C144.2 C145.2 C146.1 C147.2 C148.1 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.1 C158.2 C159.1 C161.2 C162.1 C163.2 C164.2 C165.2 C166.2 C167.2 C168.1 C169.1 C170.2 C171.1 C172.1 C173.2 C174.2 C175.1 C176.1 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.1 C185.2 C186.2 C187.2 C188.1 C189.2 C190.2 C191.2 C192.2 C193.1 C195.1 C196.2 C197.2 C198.1 C199.2 C200.1 C201.1 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C209.1 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.1 C221.1 C222.2 C223.2 C224.1 C225.2 C226.1 C227.2 C228.2 C229.1 C230.2 C231.1 C232.1 C233.2 C234.1 C235.2 C236.1 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.1 C246.1 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.1 C258.2 C259.2 C260.2 C261.2 C262.1 C263.1 C264.2 C265.1 C266.2 C267.2 C268.1 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.1 C277.2 C280.2 C282.2 C283.2 C284.1 C285.2 C286.2 C287.2 C288.1 C289.2 C291.2 C293.2 C295.2 C300.2 C302.1 C303.2 C306.2 C310.2 C311.2 C312.2 C314.1 C315.1 C324.2 C326.2 C329.1 C330.2 C331.2 C332.2 C334.2 C335.2 C338.2 C341.1 C344.2 C345.2 C348.2 C349.2 C350.2 C352.2 C353.1 C354.2 C355.2 C357.2 C358.1 C359.2 C360.1 C364.2 C365.2 C367.2 C368.2 C369.2 C370.1 C371.2 C373.1 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.1 C382.1 C383.2 C384.2 C385.2 C386.2 C387.1 C388.2 C389.2 C390.2 C391.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.1 C419.1 C420.1 C423.2 C424.2 C425.2 C426.2 C428.1 C429.2 C430.1 C431.2 C432.1 C433.2 C437.2 C438.2 C439.1 C441.2 C442.1 C444.1 C446.2 C455.2 C456.2 C457.1 C460.2 C464.1 C466.2 C467.2 C470.1 C477.2 C478.2 C479.2 C480.1 C481.1 C482.1 C483.2 C484.2 C485.2 C486.2 C487.2 C488.2 C489.2 C490.2 C491.2 C703.1 C725.2 C726.1 C731.1 C927.1 C928.2 C929.2 C930.2 C931.1 C933.2 C934.2 C935.2 C936.2 C937.2 C938.2 C939.2 C940.2 C941.1 C942.1 C943.1 C944.1 C945.1 C946.2 C947.1 C948.1 C949.2 C950.2 C951.1 C952.1 C953.1 C954.1 C955.2 C956.1 C957.2 C958.2 C959.1 C960.2 C961.2 C962.2 C963.2 C964.2 C965.2 CL1_CL1.1 CL1_CL2.1 CN1.1 CN1.7 CN1.18 CN1.33 CN1.39 CN1.45 CN1.51 CN1.57 CN1.63 CN1.69 CN1.75 CN1.76 CN1.77 CN2.1 CN2.3 CN2.21 CN2.27 CN2.33 CN2.39 CN2.45 CN2.51 CN2.57 CN2.69 CN2.71 CN2.73 CN2.75 CN2.76 CN2.77 CN3.1 CN3.2 CN3.3 CN3.4 CN3.A1 CN3.A12 CN3.B1 CN3.B12 CN6.1 CN6.4 CN7.5 CN8.4 CN8.5 CN8.7 CN8.8 CN9.1 CN9.4 CN9.7 CN9.10 CN9.21 CN9.24 CN9.25 CN9.33 CN9.34 CN10.3 CN10.5 CN10.7 CN10.8 CN11.2 CN11.27 CN11.28 CN12.4 CN12.7 CN12.8 CN13.3 CN13.4 CN14.3 CN14.4 CN16.5 CN16.9 CN16.10 CN17.4 CN17.9 CN17.10 CN18.1 CN18.2 CN18.3 CN18.4 CN18.A1 CN18.A12 CN18.B1 CN18.B12 D1.2 D2.1 D4.2 D6.2 D7.2 D8.2 D9.2 D10.2 D11.2 D12.2 D13.2 D14.2 D15.2 D16.2 D17.2 D25.2 D26.2 D27.2 D29.2 D30.2 D32.2 D33.2 D37.2 D49.1 D50.1 D51.2 EC1.1 EC2.1 EC3.1 EC4.1 EC5.1 EC6.1 EC7.1 EC8.1 EC9.1 EC10.1 EC11.1 HOLE1.1 HOLE2.1 HOLE3.1 HOLE5.1 HOLE7.1 HOLE8.1 HOLE9.1 HOLE10.1 HOLE11.1 HOLE12.1 L15.2 MR1.3 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.1 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC19.2 PC20.2 PC21.2 PC22.2 PC23.2 PC24.2 PC25.1 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.1 PC39.1 PC40.1 PC41.2 PC42.2 PC43.2 PC44.2 PC45.2 PC46.2 PC47.1 PC48.2 PC49.2 PC50.2 PC51.2 PC52.2 PC53.2 PC54.1 PC55.2 PC56.2 PC57.1 PC58.2 PC59.2 PC60.2 PC61.2 PC62.1 PC63.1 PC64.1 PC65.1 PC66.2 PC67.2 PC68.2 PC69.2 PC70.2 PC71.2 PC72.2 PC73.2 PC74.2 PC75.2 PC76.2 PC77.2 PC78.2 PC79.1 PC80.1 PC81.1 PC82.2 PC83.1 PC84.2 PC85.2 PC87.2 PC88.1 PC89.2 PC90.1 PC91.2 PC93.2 PC94.2 PC95.1 PC96.2 PC97.1 PC98.2 PC99.2 PC100.1 PC101.1 PC102.2 PC103.2 PC104.2 PC107.2 PC108.2 PC110.2 PC111.1 PC112.2 PC113.2 PC114.2 PC115.1 PC116.1 PC117.2 PC118.1 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC127.2 PC128.1 PC129.2 PC130.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC139.2 PC140.2 PC141.1 PC145.2 PC146.2 PC147.2 PC148.2 PC150.2 PC152.2 PC153.2 PC155.1 PC156.2 PC157.1 PC158.2 PC159.2 PC161.2 PC162.2 PC166.2 PC167.2 PC170.2 PC171.2 PC172.2 PC173.1 PC175.1 PC176.2 PC177.1 PC178.2 PC179.2 PC181.2 PC184.2 PC185.1 PC186.2 PC187.1 PC188.1 PC189.2 PC190.2 PC191.2 PC192.2 PC193.1 PC198.1 PC199.2 PC201.1 PC203.2 PC204.2 PC206.1 PC208.2 PC209.2 PC211.1 PC212.2 PC213.2 PC214.1 PC215.2 PC216.2 PC217.2 PC219.2 PC220.1 PC221.2 PC222.1 PC223.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC229.1 PC230.2 PC231.2 PC232.2 PC233.2 PC234.2 PC235.1 PC236.2 PC237.2 PC238.1 PC239.1 PC240.2 PC241.2 PC242.2 PC243.1 PC244.2 PC245.2 PC248.1 PC249.2 PC250.2 PC251.2 PC255.2 PC256.2 PD3.2 PD5.2 PD6.2 PQ1.5 PQ1.6 PQ1.7 PQ2.5 PQ2.6 PQ2.7 PQ3.5 PQ3.6 PQ3.7 PQ4.5 PQ4.6 PQ4.7 PQ5.5 PQ5.6 PQ5.7 PQ6.5 PQ6.6 PQ6.7 PQ7.5 PQ7.6 PQ7.7 PQ10.5 PQ10.6 PQ10.7 PQ15.1 PQ15.4 PQ16.1 PQ19.1 PQ22.1 PQ22.4 PQ28.1 PR2.1 PR19.1 PR26.2 PR30.2 PR31.1 PR42.1 PR44.1 PR47.1 PR49.1 PR53.1 PR56.1 PR61.2 PR72.2 PR73.2 PR78.1 PR80.1 PR86.2 PR102.1 PR103.1 PR105.1 PR107.2 PR116.1 PR118.1 PR124.1 PR130.1 PR133.1 PR167.1 PR174.2 PR175.2 PR185.1 PR187.1 PR188.1 PR189.2 PR195.1 PR201.2 PR202.2 PR207.2 PR208.2 PR215.2 PR221.2 PR225.2 PR226.2 PR227.2 PR234.1 PR247.2 PR249.2 PR251.2 PR255.1 PR270.2 PR273.1 PR274.2 PR276.2 PR281.2 PR282.2 PR283.1 PR300.1 PR307.1 PR316.2 PR317.2 PR320.1 PR324.1 PR328.1 PR332.2 PR334.2 PR335.1 PR337.2 PR495.2 PR496.1 PR498.1 PR499.1 PR500.1 PR501.1 PR508.2 PR510.2 PR512.2 PR513.2 PR516.2 PR518.2 PR523.2 PU1.11 PU1.15 PU2.6 PU2.9 PU3.11 PU3.15 PU4.2 PU4.4 PU5.A4 PU5.A7 PU5.A10 PU5.B7 PU5.C1 PU5.D4 PU5.D13 PU5.E2 PU5.F1 PU5.F6 PU5.F7 PU5.F8 PU5.G1 PU5.G5 PU5.G6 PU5.G7 PU5.G8 PU5.G12 PU5.G13 PU5.H5 PU5.H6 PU5.H7 PU5.H8 PU5.J5 PU5.J6 PU5.J7 PU5.J8 PU5.K1 PU5.K6 PU5.K7 PU5.L13 PU5.N3 PU5.N10 PU6.11 PU6.15 PU7.2 PU7.11 PU8.3 PU9.11 PU9.15 PU10.3 PU11.2 PU11.11 PU12.53 PU13.11 PU13.15 PU14.22 PU14.29 PU14.30 PU14.31 PU14.32 PU14.33 PU14.34 PU14.35 PU14.36 PU14.37 PU14.38 PU15.11 PU16.2 PU17.2 PU18.3 PU19.3 PU20.3 PU21.2 PU22.11 PU22.15 Q14.1 Q15.1 Q16.1 Q16.4 Q17.1 Q20.1 Q21.1 Q22.1 Q23.1 Q29.1 Q30.1 Q31.1 Q6068.1 Q6069.1 Q6071.1 R4L1.1 R4L2.1 R5L1.1 R5L2.1 R6.2 R6L1.1 R6L2.1 R6L3.1 R7.1 R7A1.1 R20.2 R25.2 R30.2 R36.1 R37.1 R40.2 R53.2 R59.2 R62.2 R65.2 R68.2 R70.2 R71.2 R74.2 R81.2 R82.2 R84.2 R93.2 R98.2 R101.2 R105.1 R122.1 R125.1 R126.1 R127.1 R129.1 R139.2 R140.2 R143.1 R144.1 R176.1 R183.2 R193.1 R208.1 R214.1 R222.1 R223.2 R229.2 R236.1 R243.1 R247.1 R252.1 R257.1 R264.1 R280.1 R282.1 R292.2 R300.2 R301.1 R302.2 R305.2 R309.2 R319.2 R324.1 R333.2 R347.2 R351.1 R362.1 R363.1 R365.2 R371.1 R373.1 R396.2 R397.1 R402.1 R426.2 R430.1 R434.1 R435.1 R439.2 R442.2 R445.1 R446.1 R452.1 R457.1 R474.2 R475.2 R482.1 R487.1 R494.2 R499.1 R659.1 R10951.2 R10962.1 R10964.2 R10983.2 R10991.2 R10995.1 R10996.2 R10999.2 R11002.2 R11004.2 R11005.1 R11007.1 R11008.1 R11016.1 R11019.1 SPAD1.1 SPAD2.1 SPAD3.1 SPAD4.1 SPAD7.1 SPAD8.1 SPAD9.1 SPAD10.1 SPAD11.1 SPAD12.1 SPAD13.1 SPAD14.1 SPAD15.1 SPAD16.1 SPAD17.1 SPAD18.1 SPAD19.1 SPAD20.1 SPAD22.1 SW1.3 SW1.4 SW3.1 SW3.2 TP27.1 U1.4 U2.3 U3.A5 U3.A14 U3.AA24 U3.AA27 U3.AA30 U3.AA33 U3.AA36 U3.AA40 U3.AA43 U3.AA44 U3.AA46 U3.AA47 U3.AA49 U3.AA50 U3.AA51 U3.AA55 U3.AA57 U3.AA59 U3.AA61 U3.AA63 U3.AB13 U3.AC15 U3.AC16 U3.AC18 U3.AC19 U3.AC21 U3.AC27 U3.AC33 U3.AC36 U3.AC40 U3.AD13 U3.AE2 U3.AE4 U3.AE8 U3.AE10 U3.AE21 U3.AE30 U3.AE43 U3.AE44 U3.AE46 U3.AE47 U3.AE49 U3.AE50 U3.AE51 U3.AF13 U3.AF15 U3.AF16 U3.AF21 U3.AF23 U3.AF33 U3.AF36 U3.AF40 U3.AF54 U3.AF56 U3.AF58 U3.AF60 U3.AF62 U3.AF64 U3.AG59 U3.AH16 U3.AH23 U3.AH24 U3.AH27 U3.AH30 U3.AH33 U3.AH36 U3.AH40 U3.AH43 U3.AH44 U3.AH46 U3.AH47 U3.AH49 U3.AH50 U3.AH51 U3.AH54 U3.AJ59 U3.AK1 U3.AK3 U3.AK5 U3.AK7 U3.AK9 U3.AK11 U3.AK13 U3.AK15 U3.AK16 U3.AK24 U3.AK27 U3.AK33 U3.AK36 U3.AK40 U3.AK54 U3.AL16 U3.AL21 U3.AL24 U3.AL27 U3.AL30 U3.AL33 U3.AL36 U3.AL40 U3.AL43 U3.AL44 U3.AL46 U3.AL47 U3.AL49 U3.AL50 U3.AL51 U3.AL53 U3.AL59 U3.AM54 U3.AM64 U3.AN16 U3.AN18 U3.AN19 U3.AN21 U3.AN24 U3.AN27 U3.AN33 U3.AN36 U3.AN40 U3.AN59 U3.AP54 U3.AP64 U3.AR2 U3.AR4 U3.AR6 U3.AR8 U3.AR10 U3.AR12 U3.AR15 U3.AR18 U3.AR27 U3.AR30 U3.AR33 U3.AR36 U3.AR40 U3.AR43 U3.AR44 U3.AR46 U3.AR47 U3.AR49 U3.AR50 U3.AR51 U3.AR59 U3.AT27 U3.AT54 U3.AU53 U3.AU55 U3.AU57 U3.AU59 U3.AU61 U3.AU63 U3.AV16 U3.AV20 U3.AV24 U3.AV52 U3.AV54 U3.AW17 U3.AW19 U3.AW21 U3.AW23 U3.AW25 U3.AY16 U3.AY24 U3.AY26 U3.AY28 U3.AY30 U3.AY32 U3.AY34 U3.AY36 U3.AY38 U3.AY40 U3.AY42 U3.AY44 U3.AY46 U3.AY48 U3.AY50 U3.AY52 U3.BA1 U3.BA3 U3.BA5 U3.BA7 U3.BA9 U3.BA11 U3.BA53 U3.BA58 U3.BA64 U3.BB20 U3.BB22 U3.BB24 U3.BB26 U3.BB28 U3.BB30 U3.BB32 U3.BB34 U3.BB36 U3.BB38 U3.BB40 U3.BB42 U3.BB44 U3.BB46 U3.BB48 U3.BB50 U3.BB52 U3.BB54 U3.BB59 U3.BC17 U3.BC29 U3.BC47 U3.BD20 U3.BD38 U3.BD56 U3.BD63 U3.BE12 U3.BE29 U3.BE31 U3.BE33 U3.BE35 U3.BE47 U3.BF20 U3.BF38 U3.BF56 U3.BF59 U3.BG2 U3.BG4 U3.BG6 U3.BG8 U3.BG12 U3.BG15 U3.BG17 U3.BG29 U3.BG63 U3.BH20 U3.BH22 U3.BH24 U3.BH26 U3.BH28 U3.BH32 U3.BH34 U3.BH36 U3.BH38 U3.BH40 U3.BH42 U3.BH44 U3.BH46 U3.BH48 U3.BH50 U3.BH52 U3.BH54 U3.BH56 U3.BH59 U3.BJ29 U3.BJ47 U3.BJ62 U3.BK20 U3.BK38 U3.BK56 U3.BL1 U3.BL8 U3.BL29 U3.BL31 U3.BL33 U3.BL35 U3.BL47 U3.BM11 U3.BM14 U3.BM16 U3.BM18 U3.BM20 U3.BM38 U3.BN6 U3.BN29 U3.BP1 U3.BP22 U3.BP28 U3.BP30 U3.BP36 U3.BP38 U3.BP44 U3.BP46 U3.BP52 U3.BP54 U3.BP60 U3.BP62 U3.C14 U3.C40 U3.D1 U3.D6 U3.D8 U3.D10 U3.D62 U3.E14 U3.E16 U3.E18 U3.E20 U3.E22 U3.E24 U3.E26 U3.E28 U3.E30 U3.E32 U3.E34 U3.E36 U3.E38 U3.E40 U3.E42 U3.E44 U3.E46 U3.E48 U3.E50 U3.E52 U3.E54 U3.E56 U3.E59 U3.F62 U3.G14 U3.J3 U3.J5 U3.J7 U3.J9 U3.J14 U3.J62 U3.K15 U3.K17 U3.K19 U3.K21 U3.K23 U3.K25 U3.K27 U3.K29 U3.K31 U3.K33 U3.K35 U3.K37 U3.K39 U3.K41 U3.K43 U3.K45 U3.K47 U3.K49 U3.K51 U3.K53 U3.K55 U3.L14 U3.L57 U3.L59 U3.L61 U3.M3 U3.N14 U3.N16 U3.N18 U3.N20 U3.N22 U3.N24 U3.N26 U3.P54 U3.R2 U3.R4 U3.R6 U3.R8 U3.R10 U3.R18 U3.R24 U3.R30 U3.R33 U3.R36 U3.R40 U3.R43 U3.R44 U3.R46 U3.R47 U3.R49 U3.R50 U3.R55 U3.T13 U3.T18 U3.T21 U3.T23 U3.T24 U3.T33 U3.T36 U3.T40 U3.T56 U3.T58 U3.T60 U3.T62 U3.T64 U3.V13 U3.V24 U3.V27 U3.V30 U3.V33 U3.V36 U3.V40 U3.V43 U3.V44 U3.V46 U3.V47 U3.V49 U3.V50 U3.V51 U3.Y1 U3.Y3 U3.Y5 U3.Y7 U3.Y9 U3.Y11 U3.Y13 U3.Y15 U3.Y16 U3.Y24 U3.Y27 U3.Y33 U3.Y36 U3.Y40 U4.3 U4A1.B2 U4A1.B5 U4A1.B6 U4A1.B12 U4A1.C3 U4A1.C5 U4A1.C6 U4A1.D3 U4A1.D8 U4A1.D12 U4A1.E4 U4A1.E5 U4A1.E6 U4A1.F4 U4A1.F5 U4A1.F6 U4A1.F12 U4A1.G3 U4A1.G4 U4A1.G6 U4A1.G8 U4A1.G9 U4A1.H2 U4A1.H10 U4A1.J4 U4A1.J12 U4A1.K2 U4A1.K10 U4A1.L6 U4A1.L8 U4A1.L9 U4A1.M4 U4A1.M5 U4A1.M6 U4A1.M12 U4A1.N4 U4A1.N5 U4A1.N6 U4A1.P3 U4A1.P8 U4A1.P12 U4A1.R4 U4A1.R5 U4A1.R6 U4A1.T2 U4A1.T3 U4A1.T4 U4A1.T5 U4A1.T6 U4A1.T12 U5.5 U5.10 U5.12 U5.13 U5.15 U5.16 U5A1.B2 U5A1.B5 U5A1.B6 U5A1.B12 U5A1.C3 U5A1.C5 U5A1.C6 U5A1.D3 U5A1.D8 U5A1.D12 U5A1.E4 U5A1.E5 U5A1.E6 U5A1.F4 U5A1.F5 U5A1.F6 U5A1.F12 U5A1.G3 U5A1.G4 U5A1.G6 U5A1.G8 U5A1.G9 U5A1.H2 U5A1.H10 U5A1.J4 U5A1.J12 U5A1.K2 U5A1.K10 U5A1.L6 U5A1.L8 U5A1.L9 U5A1.M4 U5A1.M5 U5A1.M6 U5A1.M12 U5A1.N4 U5A1.N5 U5A1.N6 U5A1.P3 U5A1.P8 U5A1.P12 U5A1.R4 U5A1.R5 U5A1.R6 U5A1.T2 U5A1.T3 U5A1.T4 U5A1.T5 U5A1.T6 U5A1.T12 U6A1.B2 U6A1.B5 U6A1.B6 U6A1.B12 U6A1.C3 U6A1.C5 U6A1.C6 U6A1.D3 U6A1.D8 U6A1.D12 U6A1.E4 U6A1.E5 U6A1.E6 U6A1.F4 U6A1.F5 U6A1.F6 U6A1.F12 U6A1.G3 U6A1.G4 U6A1.G6 U6A1.G8 U6A1.G9 U6A1.H2 U6A1.H10 U6A1.J4 U6A1.J12 U6A1.K2 U6A1.K10 U6A1.L6 U6A1.L8 U6A1.L9 U6A1.M4 U6A1.M5 U6A1.M6 U6A1.M12 U6A1.N4 U6A1.N5 U6A1.N6 U6A1.P3 U6A1.P8 U6A1.P12 U6A1.R4 U6A1.R5 U6A1.R6 U6A1.T2 U6A1.T3 U6A1.T4 U6A1.T5 U6A1.T6 U6A1.T12 U7A1.B2 U7A1.B5 U7A1.B6 U7A1.B12 U7A1.C3 U7A1.C5 U7A1.C6 U7A1.D3 U7A1.D8 U7A1.D12 U7A1.E4 U7A1.E5 U7A1.E6 U7A1.F4 U7A1.F5 U7A1.F6 U7A1.F12 U7A1.G3 U7A1.G4 U7A1.G6 U7A1.G8 U7A1.G9 U7A1.H2 U7A1.H10 U7A1.J4 U7A1.J12 U7A1.K2 U7A1.K10 U7A1.L6 U7A1.L8 U7A1.L9 U7A1.M4 U7A1.M5 U7A1.M6 U7A1.M12 U7A1.N4 U7A1.N5 U7A1.N6 U7A1.P3 U7A1.P8 U7A1.P12 U7A1.R4 U7A1.R5 U7A1.R6 U7A1.T2 U7A1.T3 U7A1.T4 U7A1.T5 U7A1.T6 U7A1.T12 U8.3 U9.6 U10.11 U10.12 U10.13 U10.14 U10.15 U10.16 U11.3 U13.41 U14.9 U15.5 U15.11 U15.20 U15.21 U16.1 U17.D6 U17.E10 U17.F5 U17.G4 U17.G5 U17.H5 U18.1 U19.49 U20.F5 U20.F6 U20.H1 U21.2 U39.3 U40.41 U41.3 U42.3 U43.11 U43.12 U43.13 U43.14 U43.15 U43.16 U44.3 Y1.2 Y1.4
PVDD: L12.1 Q28.1 R417.1
V0.85A_ENA: PR97.2 PR264.1
V0P85A_VID0: PR342.1 U3.BA13
V0P85A_VID1: PR341.1 U3.BB12
V1.00A_SRC: PC75.1 PC76.1 PC123.1 PC124.1 PL9.2 PR172.2 PR177.2
V1.00A_VIN: PC112.1 PC113.1 PC114.1 PQ5.2 PQ5.3 PQ5.4 PQ5.9 PR171.1
V1.00S_PG: PR91.2 PR151.1 PR157.1
V1.8A_SRC: PC73.1 PC74.1 PL10.2 PR55.1 PR173.2
V1.8U_2.5U_LSW: PR63.1 PR94.2
V3.3A_DSW_VIN: PC68.1 PC69.1 PC70.1 PQ4.2 PQ4.3 PQ4.4 PQ4.9 PR52.1 PR123.2
V3.3A_PCH_LSW: PR93.2 PR113.2
V3.3A_PCH_S2: PC58.1 PR48.1 PU6.8 PU6.9
V4_VCCIO: C150.1 C163.1 C177.1 C191.1 C206.1 C229.2 C230.1 C234.2 C236.2 C237.1 C239.1 C240.1 C241.1 C242.1 C243.1 C244.1 C247.1 C259.1 C267.1 C928.1 C929.1 C930.1 C933.1 PR51.2 PR99.2 R50.2 R175.2 U3.AC23 U3.AC24 U3.AE23 U3.AE24 U3.AE26 U3.AF24 U3.AF26 U3.AH26 U3.AK26 U3.AL26 U3.AN26 U3.AR26 U3.AT26 U3.AV26 U3.AV28 U3.AV30 U3.AV32 U3.AV34 U3.AV36 U3.AV38 U3.AV40 U3.AV42 U3.AV44 U3.AV46 U3.AV48 U3.AV50 U3.AW27 U3.AW29 U3.AW31 U3.AW33 U3.AW35 U3.AW37 U3.AW39 U3.AW41 U3.AW43 U3.AW45 U3.AW47 U3.AW49 U3.AW51
V4_VCCIO_PG_IC: PR32.1 PR33.2 PR77.1
V4_VCCIO_VCCSENSE: PR169.1 U3.AT24
V4_VCCIO_VSSSENSE: PR168.1 U3.AR24
V5_V5A_DS3: PC16.1 PC133.1 PC255.1 PC256.1 PR182.2 PR224.1 PR524.2 PU2.4 PU12.18
V5_V5A_DS3_PG: PQ16.2 PQ19.2 PQ28.2 PR109.2 PR110.1 PR149.1 PR316.1 PR337.1 PR510.1
V5_V5A_DS3_R: PC250.1 PR524.1 PU22.13 PU22.14
V5_V5A_DSW: C284.2 C289.1 C293.1 C945.2 C946.1 C956.2 C957.1 C958.1 PC186.1 PC249.1 PD10.2 PD12.2 PR3.1 PR43.1 PU13.6 PU13.7 PU22.1 PU22.2 R117.1 R121.1 R274.1 R11001.1 U10.3 U10.4 U10.5 U16.2 U18.2 U43.3 U43.4 U43.5
V5A_DS3_SRC: PC7.1 PC8.1 PC9.1 PC10.1 PC11.1 PL2.2 PR3.2 PR4.2
V5A_DS3_VIN: EC4.2 EC5.2 EC6.2 PC22.1 PC23.1 PQ3.2 PQ3.3 PQ3.4 PQ3.9 PR9.1 PR90.1
V6_V3.3A_DSW: C703.2 LED1.2 LED2.2 LED3.2 LED4.2 LED5.3 LED6.3 PC28.1 PC30.1 PC31.1 PC32.1 PC33.1 PC34.1 PC50.1 PC110.1 PC122.1 PC158.1 PL5.2 PR10.1 PR22.1 PR32.2 PR38.2 PR39.1 PR50.1 PR68.2 PR75.2 PR88.2 PR104.1 PR117.1 PR119.1 PR121.1 PR128.1 PR148.1 PR156.2 PR157.2 PR158.2 PR159.2 PR160.2 PR205.1 PR220.2 PR222.2 PR223.2 PR233.2 PR236.1 PR243.1 PR306.2 PR312.2 PU3.1 PU3.2 PU5.L8 PU6.6 PU6.7 PU9.6 PU9.7 PU13.1 PU13.2 Q25.2 Q26.2 Q26.5 R4.1 R48.1 R90.1 R115.2 R149.2 R285.2 R290.1 R311.1 R393.1 R399.1 R414.1 R416.1 R503.1 R860.2 R10930.2 R10985.1 R10987.1 R10989.1
V6_V3.3A_DSW_PG: PR119.2 PU5.B9 U17.M3
V7_V3.3A_PCH: C12.1 C13.2 C155.1 C167.1 C171.2 C186.1 C210.1 C221.2 C222.1 C227.1 C238.1 C246.2 PC62.2 PR13.1 PR48.2 Q6063.1 Q6064.2 Q6064.5 Q6072.2 Q6072.5 R29.1 R33.2 R34.2 R38.1 R46.2 R51.2 R52.1 R54.1 R55.1 R56.1 R57.1 R58.1 R61.2 R64.1 R67.2 R69.1 R75.1 R76.1 R77.1 R80.1 R86.1 R87.1 R92.1 R103.1 R104.2 R124.2 R128.2 R130.2 R133.2 R188.2 R189.1 R190.2 R191.2 R192.2 R205.1 R206.1 R211.2 R298.2 R310.1 R325.1 R326.1 R332.2 R337.2 R502.1 R504.2 R505.1 R10942.2 R10943.2 R10957.2 R10966.2 R10967.2 R10968.2 R10969.2 R10970.2 R10971.1 R10972.1 R10973.1 R10974.1 R10975.1 U2.5 U3.AA2 U3.AB1 U3.AC2 U3.AD1 U3.AF1 U3.AG2 U3.AH1 U3.AH21 U3.AJ2 U3.AK19 U3.AK21 U3.AL19 U3.AN15 U3.AP13 U3.AT1 U3.AU2 U3.AV1 U3.AW2
V7_V3.3A_PCH_PG: PR136.2 PU5.C12
V8_V1.8A: C170.1 C207.1 PC85.1 PR55.2 PR76.1 PU1.6 PU1.7 U3.AE15 U3.AE16 U3.AN2 U3.AP1
V8_V1.8A_PG: PR148.2 PR340.1 PU5.E12 R10959.2
V8_V1.8A_PG_GPJ1: R10959.1 R10960.1 U17.D13
V10_V1.2U: C5L1.1 C5L4.1 C6A1.1 C6A3.1 C6A6.2 C6A7.1 C6A8.1 C6L1.1 C6L3.1 C6L4.1 C6L6.1 C6L9.2 C7A1.1 C7A2.2 C7L1.2 C7L3.2 C7L4.2 C7L5.2 C7L7.2 C7L8.2 C7L9.1 C7L11.2 C7L12.2 C7L13.1 C7L14.2 C7L15.2 C7L16.2 C209.2 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C258.1 C260.1 C261.1 C263.2 C264.1 C265.2 C266.1 C268.2 C270.1 C271.1 C272.1 C273.1 C274.1 C275.1 C276.2 C312.1 C324.1 C326.1 C416.1 C417.1 C423.1 C424.1 C425.1 C426.1 C934.1 C935.1 C936.1 C937.1 C938.1 C939.1 C940.1 PC20.1 PR7.1 PR29.2 PU1.1 PU1.2 R200.2 R258.2 R306.2 R10965.2 U3.AH64 U3.AK64 U3.AT64 U3.AV64 U3.BA25 U3.BA27 U3.BA29 U3.BA31 U3.BA33 U3.BA35 U3.BA37 U3.BA41 U3.BA43 U3.BA45 U3.BA47 U3.BA49 U3.BA51 U3.BN64 U3.BP24 U3.BP26 U3.BP32 U3.BP34 U3.BP40 U3.BP42 U3.BP48 U3.BP50 U3.BP56 U3.BP58 U3.BP64 U4A1.A8 U4A1.A9 U4A1.A11 U4A1.C12 U4A1.D4 U4A1.D5 U4A1.D6 U4A1.E8 U4A1.E12 U4A1.F2 U4A1.G2 U4A1.G5 U4A1.G12 U4A1.H3 U4A1.H5 U4A1.H6 U4A1.H8 U4A1.H9 U4A1.H11 U4A1.H12 U4A1.J5 U4A1.J6 U4A1.J9 U4A1.J10 U4A1.K5 U4A1.K6 U4A1.K8 U4A1.K11 U4A1.K12 U4A1.L2 U4A1.L5 U4A1.L12 U4A1.M2 U4A1.N8 U4A1.N12 U4A1.P4 U4A1.P5 U4A1.P6 U4A1.R12 U4A1.U8 U4A1.U9 U4A1.U11 U5A1.A8 U5A1.A9 U5A1.A11 U5A1.C12 U5A1.D4 U5A1.D5 U5A1.D6 U5A1.E8 U5A1.E12 U5A1.F2 U5A1.G2 U5A1.G5 U5A1.G12 U5A1.H3 U5A1.H5 U5A1.H6 U5A1.H8 U5A1.H9 U5A1.H11 U5A1.H12 U5A1.J5 U5A1.J6 U5A1.J9 U5A1.J10 U5A1.K5 U5A1.K6 U5A1.K8 U5A1.K11 U5A1.K12 U5A1.L2 U5A1.L5 U5A1.L12 U5A1.M2 U5A1.N8 U5A1.N12 U5A1.P4 U5A1.P5 U5A1.P6 U5A1.R12 U5A1.U8 U5A1.U9 U5A1.U11 U6A1.A8 U6A1.A9 U6A1.A11 U6A1.C12 U6A1.D4 U6A1.D5 U6A1.D6 U6A1.E8 U6A1.E12 U6A1.F2 U6A1.G2 U6A1.G5 U6A1.G12 U6A1.H3 U6A1.H5 U6A1.H6 U6A1.H8 U6A1.H9 U6A1.H11 U6A1.H12 U6A1.J5 U6A1.J6 U6A1.J9 U6A1.J10 U6A1.K5 U6A1.K6 U6A1.K8 U6A1.K11 U6A1.K12 U6A1.L2 U6A1.L5 U6A1.L12 U6A1.M2 U6A1.N8 U6A1.N12 U6A1.P4 U6A1.P5 U6A1.P6 U6A1.R12 U6A1.U8 U6A1.U9 U6A1.U11 U7A1.A8 U7A1.A9 U7A1.A11 U7A1.C12 U7A1.D4 U7A1.D5 U7A1.D6 U7A1.E8 U7A1.E12 U7A1.F2 U7A1.G2 U7A1.G5 U7A1.G12 U7A1.H3 U7A1.H5 U7A1.H6 U7A1.H8 U7A1.H9 U7A1.H11 U7A1.H12 U7A1.J5 U7A1.J6 U7A1.J9 U7A1.J10 U7A1.K5 U7A1.K6 U7A1.K8 U7A1.K11 U7A1.K12 U7A1.L2 U7A1.L5 U7A1.L12 U7A1.M2 U7A1.N8 U7A1.N12 U7A1.P4 U7A1.P5 U7A1.P6 U7A1.R12 U7A1.U8 U7A1.U9 U7A1.U11
V10_V1.2U_AE27: C142.2 R146.1 U3.AE27 U3.AF27
V10_V1.2U_PG: PR95.2 PR151.2 PU5.J13
V11_V1.00A: C41.1 C50.1 C62.2 C68.1 C84.2 C85.2 C94.1 C101.2 C103.2 C104.2 C108.2 C112.2 C116.2 C131.2 C168.2 C172.2 C175.2 C176.2 C184.2 C188.2 C201.2 C477.1 C478.1 C479.1 C480.2 C481.2 EC7.2 EL1.1 PC41.1 PC49.1 PC126.1 PR147.1 PR177.1 PU3.6 PU3.7 PU6.1 PU6.2 PU9.1 PU9.2 R22.2 U3.AA15 U3.AA16 U3.AA21 U3.AA23 U3.AH13 U3.AH15 U3.AH18 U3.AH19 U3.AK18 U3.AK23 U3.AL18 U3.AL23 U3.AN23 U3.AR21 U3.AR23 U3.AT21 U3.R15 U3.R16 U3.R19 U3.R21 U3.R23 U3.T1 U3.T15 U3.T16 U3.T19 U3.U2 U3.V1 U3.V15 U3.V16 U3.V18 U3.V19 U3.V21 U3.V23 U3.W2 U3.Y18 U3.Y19 U3.Y21 U3.Y23
V11_V1.00A_PG: PR128.2 PU5.M9 R10948.2
V12_V0.85A: C159.2 C200.2 PR176.2 U3.AE18 U3.AE19 U3.AF18 U3.AF19 U3.AR16 U3.AT16
V12_V0.85A_PG: PR18.2 PR143.2
V12_V0.85A_PG_IC: PR54.1 PR231.2 PR233.1
VCCCOREG0: C87.1 C92.1 C97.1 C102.1 C110.1 C113.1 C124.1 C128.1 C133.1 C136.1 C144.1 C147.1 U3.AA35 U3.AA38 U3.AC35 U3.AC38 U3.R35 U3.R38 U3.T35 U3.T38 U3.V35 U3.V38 U3.Y35 U3.Y38
VCCCOREG1: C154.1 C156.1 C165.1 C166.1 C180.1 C181.1 C189.1 C190.1 C204.1 C205.1 C214.1 C215.1 U3.AF35 U3.AF38 U3.AH35 U3.AH38 U3.AK35 U3.AK38 U3.AL35 U3.AL38 U3.AN35 U3.AN38 U3.AR35 U3.AR38
VCCGT: C64.1 C65.1 C66.1 C71.1 C96.1 C98.1 C99.1 C100.1 C117.1 C118.1 C119.1 C121.1 C122.1 C123.2 C137.1 C138.1 C139.1 C141.2 C152.1 C153.1 C161.1 C162.2 C173.1 C174.1 C185.1 C196.1 C197.1 C199.1 C216.1 C217.1 C219.2 C225.1 C228.1 C231.2 C232.2 C233.1 C235.1 C483.1 C484.1 C485.1 C486.1 C487.1 C488.1 PC103.1 PL7.2 PR37.2 PR122.1 U3.AA53 U3.AB54 U3.AB56 U3.AB58 U3.AB60 U3.AB62 U3.AB64 U3.AC43 U3.AC44 U3.AC46 U3.AC47 U3.AC49 U3.AC50 U3.AC51 U3.AC53 U3.AC55 U3.AC57 U3.AC59 U3.AC61 U3.AC63 U3.AD54 U3.AD56 U3.AD58 U3.AD60 U3.AD62 U3.AD64 U3.AE53 U3.AE55 U3.AE57 U3.AE59 U3.AE61 U3.AE63 U3.AF43 U3.AF44 U3.AF46 U3.AF47 U3.AF49 U3.AF50 U3.AF51 U3.AG53 U3.AJ53 U3.AK43 U3.AK44 U3.AK46 U3.AK47 U3.AK49 U3.AK50 U3.AK51 U3.AN43 U3.AN44 U3.AN46 U3.AN47 U3.AN49 U3.AN50 U3.AN51 U3.AT43 U3.AT44 U3.AT46 U3.AT47 U3.AT49 U3.AT50 U3.AT51 U3.N44 U3.N46 U3.N48 U3.N50 U3.R51 U3.R53 U3.T43 U3.T44 U3.T46 U3.T47 U3.T49 U3.T50 U3.T51 U3.T54 U3.U53 U3.U55 U3.U57 U3.U59 U3.U61 U3.U63 U3.V54 U3.V56 U3.V58 U3.V60 U3.V62 U3.V64 U3.W53 U3.W55 U3.W57 U3.W59 U3.W61 U3.W63 U3.Y43 U3.Y44 U3.Y46 U3.Y47 U3.Y49 U3.Y50 U3.Y51 U3.Y54 U3.Y56 U3.Y58 U3.Y60 U3.Y62 U3.Y64
VCCGT_SENSE: PR122.2 PR285.1 U3.N52
VCCIO_C0: PR30.1 PR121.2 PU7.4
VCCIO_C1: PR22.2 PR26.1 PU7.3
VCCIO_ENA: PR89.2 PR135.2
VCCIO_LP#: PR39.2 PR40.2 PU7.6
VCCPLL_OC: PC80.2 PC239.2 PR58.2 R146.2
VCCPLL_OC_S2: PC1.1 PR58.1 PU1.13 PU1.14
VCCPRTCEXT: C223.1 U3.AT18 U3.AV18
VCCSA: C42.1 C43.1 C45.1 C46.1 C47.1 C48.1 C49.1 C54.1 C61.1 C63.1 C105.2 C120.2 C132.2 C143.2 C157.2 C187.1 PC15.1 PC19.1 PL3.2 PR16.2 PR79.1 R160.1 U3.AA29 U3.AC29 U3.AC30 U3.AE29 U3.AF29 U3.AF30 U3.AH29 U3.AK29 U3.AK30 U3.AL29 U3.AN29 U3.AN30 U3.AR29 U3.L30 U3.M31 U3.N30 U3.R29 U3.T29 U3.T30 U3.V29 U3.Y29 U3.Y30
VCCSA_DDR: C59.2 C218.1 C482.2 R160.2 U3.AT29 U3.AT30
VCCSA_SENSE: PR79.2 PR301.1 U3.M29
VCCSENSE: PR81.2 PR192.1 U3.L34
VCCST_PWRGD: PR99.1 PU5.E4 R156.2 R164.1
VCCST_PWRGD_R: R164.2 U3.B61
VDD_V3P3A_RTC: D3.2 PC108.1 PU5.C13
VDDQ_SRC: PC5.1 PC12.1 PC13.1 PC14.1 PL1.2 PR7.2 PR60.2
VDDQ_VIN: EC1.2 EC2.2 EC3.2 PC17.1 PC21.1 PQ1.2 PQ1.3 PQ1.4 PQ1.9 PR6.1
VINLDO1: PC43.1 PR29.1 PU5.A6 PU5.B6
VINVR2: PC65.2 PR50.2 PU5.F12 PU5.F13
VINVR3: PR123.1 PU5.G9
VINVR5: PR90.2 PU5.L7
VSSGT_SENSE: PR118.2 PR287.1 U3.P52
VSSSA_SENSE: PR78.2 PR302.1 U3.N28
VSSSENSE: PR80.2 PR191.1 U3.L32
13_CCD_PW: CN8.1 R355.2
8350_GND: C453.2 C454.2 L15.1 R487.2 U20.A2
36001_CC1: R308.2 R309.1 U14.12
36001_CC2: R364.2 R365.1 U14.6
+1.8U: C4A1.2 C4A2.2 C4A3.2 C4A4.2 C4A5.2 C5L2.1 C5L3.1 C5L5.1 C6L2.1 C6L5.1 C7L10.2 PC6.2 PC162.1 PC167.1 PR1.1 PR45.1 PU15.7 PU15.8 R307.1 U4A1.A3 U4A1.A4 U4A1.A5 U4A1.A6 U4A1.A10 U4A1.U3 U4A1.U4 U4A1.U5 U4A1.U6 U4A1.U10 U5A1.A3 U5A1.A4 U5A1.A5 U5A1.A6 U5A1.A10 U5A1.U3 U5A1.U4 U5A1.U5 U5A1.U6 U5A1.U10 U6A1.A3 U6A1.A4 U6A1.A5 U6A1.A6 U6A1.A10 U6A1.U3 U6A1.U4 U6A1.U5 U6A1.U6 U6A1.U10 U7A1.A3 U7A1.A4 U7A1.A5 U7A1.A6 U7A1.A10 U7A1.U3 U7A1.U4 U7A1.U5 U7A1.U6 U7A1.U10
+1.8U_S2: PC4.1 PR1.2 PU1.8 PU1.9
+AZA_VDD: C375.1 C380.1 C460.1 R381.1 R432.1 U19.1 U19.36
+BAT_DIS: EC9.2 EC10.2 EC11.2 PC218.2 PL14.2 PQ12.1 PQ12.2 PQ12.3 PR212.2 PR289.1 PR291.2
+BATCHG: PC203.1 PC213.1 PC217.1 PC221.1 PL15.1 PR289.2 PR290.2
+MUX_PWR: C314.2 C315.2 C341.2 C373.2 R310.2 R311.2 R372.1 U15.1 U15.6 U15.10
+POA_PWR: C726.2 Q6062.1 R860.1 R1530.2 R10931.1 R10932.1
+PRWSRC: PC168.1 PQ11.1 PQ11.2 PQ11.3 PR260.1 PR261.2 PR278.2
+SMDDR_VREF_CA: C6A4.1 C6A9.1 C6L7.1 C6L8.1 C303.1 R279.2 R301.2 R306.1 R313.1 U4A1.H4 U5A1.H4 U6A1.H4 U7A1.H4
+SMDDR_VREF_DQA: C6A2.1 C7L6.1 C248.1 R195.2 R197.1 R200.1 R324.2 U6A1.J11 U7A1.J11
+SMDDR_VREF_DQB: C6A5.1 C7L2.1 C291.1 R254.1 R257.2 R258.1 R263.2 U4A1.J11 U5A1.J11
+SMDDR_VTERM: PC95.2 PC238.2 PR41.1 R197.2 R254.2 R313.2
+USB_RE_PWR_C: C329.2 R307.2 R308.1 R364.1 U14.3
+VA: PC230.1 PC234.1 PC236.1 PC240.1 PD1.1 PD1.2 PD5.1 PD7.2 PQ17.5 PQ20.5
+VAD: PC169.1 PC184.1 PC192.1 PD1.3 PQ11.5 PR280.1
+WL_VDD: C5.1 C6.1 C9.1 C28.1 C29.1 CN1.2 CN1.4 CN1.72 CN1.74 PC25.2 PR8.2 PR526.2 Q4.2 Q12.2 Q13.2 R91.1 R198.2 R202.1 R226.1 R231.1
A_LAD0_R: CN1.64 R106.1
A_LAD1_R: CN1.66 R111.1
A_LAD2_R: CN1.68 R116.1
A_LAD3_R: CN1.70 R120.1
AC_PRESENT: R99.2 U3.BD14 U17.B12
ACC_INT_BASE: R123.2 R430.2 U20.B5
ACC_INT_BASE_R: Q11.1 R123.1 R174.1 R180.1 U5.11
ACC_INT_PANEL: R436.2 R445.2 U20.B4
ACC_INT_PANEL_R: CN9.16 Q11.4 R178.1 R186.1 R436.1
ACIN: PR276.1 PR288.1 PU5.D11 PU14.5 Q6068.2 Q6069.2 R10964.1 R10999.1 U17.F12
ACZ_RST#_AUDIO: Q34.1 R245.1 U19.11
ACZ_SDIN: R377.1 U19.8
ACZ_SDIN0: R377.2 U3.BL15
ACZ_SDOUT_AUDIO: R262.1 U19.5
ACZ_SPK: D20.2 R83.2 U3.AV3
ACZ_SYNC_AUDIO: R242.1 U19.10
ADC0: R435.2 T62.1 U20.A5
ADC3: R446.2 T63.1 U20.A4
ADC4: R452.2 T64.1 U20.B3
ADC5: R457.2 T65.1 U20.A3
ADOGND: C367.1 C368.1 C421.2 C434.2 C436.2 C440.2 C445.2 C451.1 C452.2 C459.2 C461.2 C462.2 C468.1 C471.2 C472.2 C473.2 CN5.4 D23.2 D24.2 D28.2 D31.2 D34.2 D38.2 R139.1 R140.1 R396.1 R397.2 R472.2 R474.1 R475.1 R486.1 R493.2 R494.1 R495.1 U19.25 U19.38
ALERT#: PR259.2 PU12.37
ALL_SYS_PWRGD: C332.1 PR140.1 PU5.G11 R354.2
ALL_SYS_PWRGD_R: R354.1 U17.A10
APU_BLEN_R: Q22.2 R281.1
AUXN: C279.2 R253.2 R10950.2 U13.25
AUXP: C278.2 R252.2 U13.24
BATDIS_G: PC168.2 PC169.2 PQ11.4 PR277.2
BATLED0#: R152.1 R158.1 U17.N6
BATLED1#: R151.1 R157.1 U17.N5
BATT+: BAT1.1 BAT1.2 BAT1.3 PC227.1 PL15.2
BEEP_1: C355.1 C356.2 R346.1 R351.2
BI: BAT1.4 PR208.1 R240.1 SW2.3 SW2.4
BI_GATE: C277.1 Q16.5 Q17.2 R141.2 SW1.1 SW1.2
BIOS_CS#: R342.1 U17.A7
BIOS_RD#: R344.1 U17.A6
BIOS_SPI_CLK: R357.1 U17.B5
BIOS_WR#: R356.1 U17.B6
BIT_CLK_AUDIO: C283.1 C370.2 R238.1 U19.6
BL#: Q21.2 Q22.3 R275.1 R276.1
BL_ON: D18.2 Q21.3 Q23.3 R329.1 R427.2
BLONCON: CN9.15 R426.1 R427.1
BOARD_ID0: R80.2 R82.1 U3.AH9
BOARD_ID1: R71.1 R76.2 U3.AH11
BOARD_ID2: R92.2 R93.1 U3.AG12
BOARD_ID3: R64.2 R65.1 U3.AF9
BOARD_ID4: R56.2 R62.1 U3.AF11
BOARD_ID5: R69.2 R70.1 U3.AG8
BOARD_ID6: R57.2 R68.1 U3.AG10
BOARD_ID7: R58.2 R59.1 U3.AE12
BQACDET: PC209.1 PR274.1 PR292.1 PU14.6
BQACDRV: PR277.1 PU14.4
BQACN: PC205.2 PC215.1 PR262.1 PU14.1
BQACP: PC205.1 PC214.2 PR261.1 PU14.2
BQB_1: PC180.1 PR242.1
BQB_2: PR242.2 PU14.25
BQBATDRV: PR308.2 PU14.18
BQBATPRES: PR225.1 PR304.1 PU14.15
BQBATSRC: PR212.1 PU14.17
BQCLK: PR239.2 PU14.12
BQCMSRC: PR278.1 PU14.3
BQDATA: PR244.2 PU14.11
BQHIDRV: PQ10.1 PU14.26
BQIADP: PC204.1 PR279.2 PU14.7
BQIBAT: PC191.1 PR266.2 PU14.8
BQILIM: PR204.1 PR215.1 PU14.21
BQLODRV: PQ10.8 PU14.23
BQPHASE: PC180.2 PL14.1 PQ10.10 PR218.2 PU14.27
BQSRN: PC145.1 PC151.2 PR290.1 PU14.19
BQSRP: PC146.1 PC151.1 PR291.1 PU14.20
BQTB_STAT: PR216.1 PU14.16
BQVCC: PC189.1 PR280.2 PU14.28
BST_CORE: PC132.1 PU12.26
BST_GT1: PC131.2 PU12.14
BT_EN: CN1.54 R339.1
BT_EN_EC: C350.1 R339.2 U17.A13
CATERR#: R163.2 U3.H49
CBN: C463.2 U19.35
CBP: C463.1 U19.37
CBTL02043A_SEL: R10989.2 U15.9 U40.26
CBTL02043A_XSD: Q29.3 R371.2 R372.2 U15.2
CC_OC#: R34.1 U3.B8
CCG1_I2C_INT_D: Q25.1 R416.2 U40.15
CCG4_SWD_CLK: R10979.2 TP32.1 U40.2
CCG4_SWD_IO: R10978.2 TP31.1 U40.1
CCG4_XRES: C953.2 R10990.1 TP25.1 U40.10
CCG_I2C_INT#: Q25.3 R483.2 U17.B7
CCG_I2C_SCL: Q26.3 Q6064.3 R361.2 U17.B3
CCG_I2C_SCL_D: Q26.4 R399.2 U40.17
CCG_I2C_SDA: Q26.6 Q6064.6 R386.2 U17.B2
CCG_I2C_SDA_D: Q26.1 R414.2 U40.16
CDE: R302.1 R303.1 U13.35
CEQ: R333.1 R334.1 U13.38
CFG4: R183.1 U3.H55
CFG_RCOMP: R176.2 U3.A54
CLK_LPC_KBC: R107.1 R367.1 U17.K2
CLK_LPC_KBC_R: R107.2 U3.BJ10
CLK_PCIE_WLANN: CN1.49 U3.H35
CLK_PCIE_WLANP: CN1.47 U3.F35
CLK_WLAN_DEBUG: R112.1 R209.1
CLK_WLAN_DEBUG_C: CN1.71 R209.2
CLK_WLAN_DEBUG_R: R112.2 U3.BF5
CLKREQ_WLAN#: CN1.53 Q12.1 R194.1 R198.1
CLKRUN#: R110.2 R10973.2 U3.BH11 U17.D8
CLR_CMOS: Q14.2 Q15.2 R229.1 U17.A8
CODEC_VREF: C472.1 U19.28
COMP_CORE: PC149.2 PC150.1 PU12.30
COMP_GT: PC174.1 PC183.1 PU12.4
COMP_SA: PC197.2 PC199.1 PU12.47
CPU_SVID_ALERT#: R170.1 U3.B58
CPU_THRMTRIP#: R172.2 U3.H47
CPVEE: C464.2 U19.34
CSCOMP_GT: PC160.1 PC163.2 PR20.1 PR240.1 PR241.2 PU12.6
CSI2_COMP: R30.1 U3.A11
CSN_CORE: PC164.1 PC165.1 PR21.2 PR35.1 PU12.32
CSN_GT1: PR37.1 PR213.2
CSN_SA: PC194.2 PC207.2 PR16.1 PR28.2 PU12.45
CSP_CORE: PC164.2 PC165.2 PR228.1 PR237.1 PU12.33
CSP_GT1: PC154.1 PR186.2 PU12.10
CSP_GT2: PR224.2 PU12.9
CSP_SA: PC194.1 PC207.1 PR293.1 PR295.2 PU12.44
CSREF_GT: PC154.2 PC156.1 PR213.1 PU12.8
CSSUM_GT: PC160.2 PC163.1 PR184.2 PR232.1 PU12.7
DAS/DSS#: CN2.10 T29.1
DC-DET: R402.2 R425.1 U19.4
DDI1_AUXN: C279.1 U3.H41
DDI1_AUXP: C278.1 U3.F41
DDI1_TXN0: C337.1 U3.A46
DDI1_TXN1: C322.1 U3.C48
DDI1_TXN2: C305.1 U3.B45
DDI1_TXN3: C297.1 U3.B47
DDI1_TXP0: C351.1 U3.C46
DDI1_TXP1: C328.1 U3.A48
DDI1_TXP2: C309.1 U3.D45
DDI1_TXP3: C301.1 U3.D47
DDPB_CTRLDATA: R28.2 R10971.2 U3.H6
DDPC_CTRLDATA: R27.2 U3.F4
DDR_VTT_CTRL: PR83.2 U3.BN47
DEVSLP1: CN2.38 R73.1 R81.1 R88.2
DIFFOUT_GT: PR248.2 PR252.2 PR255.2 PU12.2
DISABLE_KB#: R459.1 R460.1 U17.C1
DISABLE_KB#_HUB: R460.2 R461.2 U20.H2
DISABLE_TP#: R466.1 R467.1 U17.M2
DISABLE_TP#_HUB: R467.2 R473.2 U20.J1
DMIC_CLK_13: CN7.7 R10954.1
DMIC_CLK_14: CN9.23 R10955.1
DMIC_CLK_R: C357.1 R10954.2 R10955.2 U19.3
DMIC_DAT_13: CN7.6 R10953.1
DMIC_DAT_14: CN9.22 R10956.1
DMIC_DAT_R: C354.1 R10953.2 R10956.2 U19.2
DNBSWON#: C364.1 R224.2 R378.2 U17.D2
DPEQ: R304.1 R305.1 U13.14
DPWROK: PR153.2 PR158.1 PU5.K12 R228.1 U17.A11
DPWROK_EC: PR152.2 R217.1 R362.2 R368.1 U17.E5
DPWROK_R: R213.2 R217.2 R223.1 R228.2 U3.BN15
DRON: PR5.1 PR258.1
DRVHVR1: PQ5.1 PU5.N12
DRVHVR3: PQ4.1 PU5.A12
DRVHVR4: PQ1.1 PU5.A2
DRVHVR5: PQ3.1 PU5.M1
DRVLVR1: PQ5.8 PU5.N9
DRVLVR3: PQ4.8 PU5.A9
DRVLVR4: PQ1.8 PU5.A5
DRVLVR5: PQ3.8 PU5.N4
EC_A20GATE: T60.1 U17.F1
EC_AOCS: PR70.2 R10960.2
EC_CE#: R1.1 R342.2
EC_FPBACK#: Q23.2 U17.B11
EC_MAINON: PR230.1 PR235.2 PR250.2 PR297.1 U17.K6
EC_MISO: R10.1 R344.2
EC_MOSI: R17.1 R356.2
EC_NBSWON#: PU5.K4 R345.2 U17.A5
EC_PCIE_WAKE#: R199.2 R10976.2
EC_PCIE_WAKE#_R: R321.2 R10976.1 U17.B8
EC_PECI: R387.2 U3.F49
EC_PWROK: R40.1 R227.1 R478.1 U2.2 U17.N7
EC_RCIN#: R114.2 R118.1 R10975.2 U17.H4
EC_RSMRST#: R207.1 R373.2 U17.A1
EC_SCK: R16.1 R357.2
EC_SMB1_CLK: Q6072.1 R330.2 R337.1 R341.2 U9.10
EC_SMB1_DATA: Q6072.4 R314.2 R323.2 R332.1 U9.9
EC_SYS_PWROK: R42.1 R501.1 U2.4
EC_VSTBY_FSPI: PC228.1 PD2.2 PR315.2 PU16.5
EC_WRST: C359.1 D22.2 PR67.2 Q16.6 R384.2 U17.L1
EC_WRST_R: PR67.1 PR68.1 PU5.J3
EDP_AUXN: C325.1 U3.J42
EDP_AUXN_C: C325.2 CN9.9
EDP_AUXP: C317.1 U3.G42
EDP_AUXP_C: C317.2 CN9.8
EDP_HPD: C442.2 R442.1 R443.2 U3.A7
EDP_HPD_R: CN9.18 R443.1
EDP_RCOMP: R175.1 U3.A50
EDP_TX_PWM: CN9.11 R408.2
EDP_TXN0: C308.1 U3.H45
EDP_TXN0_C: C308.2 CN9.5
EDP_TXN1: C304.1 U3.J44
EDP_TXN1_C: C304.2 CN9.2
EDP_TXP0: C316.1 U3.F45
EDP_TXP0_C: C316.2 CN9.6
EDP_TXP1: C307.1 U3.G44
EDP_TXP1_C: C307.2 CN9.3
EMMC_COMP: R74.1 U3.BC1
EN5VSW: PR110.2 PU5.M5
ENVR1: PR142.1 PR143.1 PU5.M12
ENVR2: PR146.1 PR152.1 PR153.1 PU5.F11
ENVR3: PR126.2 PU5.E9
ENVR4: PR14.2 PU5.C2
ENVR5: PR96.2 PR340.2 PU5.M2
ESPI_RST#: T54.1 U3.BJ6
FB_GT: PC182.1 PC183.2 PR252.1 PR253.2 PU12.3
FBLDO1: PR125.2 PU5.D8
FBVR1N: PR174.1 PU5.J9
FBVR1P: PR172.1 PU5.K10
FBVR2N: PR175.1 PU5.E10
FBVR2P: PR173.1 PU5.G10
FBVR3N: PR73.1 PU5.D7
FBVR3P: PR75.1 PU5.C10
FBVR4N: PR61.1 PU5.D5
FBVR4P: PR60.1 PU5.C3 PU5.F9
FBVR5N: PR2.2 PU5.L4
FBVR5P: PR4.1 PU5.G4
FLASH_TRIG: T41.1 U3.N4
GPG6: T70.1 U20.E2
GPIOG2: R499.2 R500.1 U20.C1
H_PROCHOT#: C413.1 PR87.2 PR265.1 PR268.2 PU14.10 Q31.3 R161.2 R168.1
H_PROCHOT#_CPU: R168.2 U3.J48
H_PROCHOT#_EC: Q31.2 R434.2 U17.M1
H_THRMDA: C292.1 Q3.2 Q3.3 U9.2
H_THRMDA2: C296.1 Q24.2 Q24.3 U9.4
H_THRMDC: C292.2 Q3.1 U9.3
H_THRMDC2: C296.2 Q24.1 U9.5
HDA_BITCLK_R: R238.2 U3.BK18
HDA_RST#_R: R245.2 U3.BL19
HDA_SDOUT_R: R244.2 R262.2 U3.BK16
HDA_SYNC_R: R242.2 U3.BJ19
HG_CORE: PR183.1 PU12.25
HG_CORE_L: PQ6.1 PR183.2
HG_GT1: PR181.1 PU12.15
HG_GT1_L: PQ7.1 PR181.2
HG_SA: PR82.1 PU2.8
HG_SA_L: PQ2.1 PR82.2
HP-L2: C447.2 R493.1 R496.1 R497.2 U19.32
HP-L3: C471.1 CN5.3 D38.1 R497.1
HP-R2: C443.2 R472.1 R477.2 R479.1 U19.33
HP-R3: C452.1 CN5.2 D34.1 R477.1
HP_JD#: CN5.5 D23.1 D24.1 R418.1
I2C0_SCL: Q48.3 R677.1 R10942.1 U3.AB3
I2C0_SDA: Q48.6 R668.1 R10943.1 U3.AD11
I2C1_SCL: Q33.3 R66.1 R455.2 R10966.1 U3.AB11
I2C1_SDA: Q33.6 R60.1 R489.2 R10967.1 U3.AB9
I2C_TP_SCL_R: CN16.3 Q48.4 R676.1 R677.2
I2C_TP_SDA_R: CN16.4 Q48.1 R668.2 R675.1
IDEA_G_3VLDO: PQ8.2 PQ9.3 PR202.1
IDEA_G_5VS5_PD_C1: PQ26.3 PQ27.2 PR518.1
IDEA_G_5VS5_PD_C2: PQ23.3 PQ24.2 PR513.1
ILIM_CORE: PC157.2 PR221.1 PU12.31
ILIM_GT: PR241.1 PU12.5
