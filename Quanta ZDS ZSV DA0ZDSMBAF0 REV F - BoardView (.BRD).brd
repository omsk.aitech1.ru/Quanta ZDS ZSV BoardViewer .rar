# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18664596:
  vias: v4(182.87,36.89)
N18664891: length 3.3
  BOTTOM w0.203: PC195.1 175.34,18.17 PR284.1 176,17.85 176.15,17.7 PC210.1 v4(176.51,17.03) 176.51,16.84 176.42,16.75 PR301.2
N18664913: length 3.2
  BOTTOM w0.203: PC196.1 176.25,18.77 176.96,18.06 PC210.2 176.96,17.13 177.11,16.98 PR296.2 177.44,16.7 PR302.2
N18665779:
  vias: v4(173.78,36.96)
N18665845: length 9.2
  TOP w0.203: v4(170.4,27.37) 170.06,27.71 170.06,31.74 v4(169.87,31.93) 168.47,33.32 PR56.2
  BOTTOM w0.203: PR203.1 170,26.8 PR201.1 169.79,27.17 170,27.37 v4(170.4,27.37)
N18665924: length 2.4
  BOTTOM w0.117: PR207.1 185.63,26.76 185.85,26.98 186.33,26.98 v4(186.66,26.65)
  BOTTOM w0.203: PR207.1 185.17,26.18 PC149.1
N18665958: length 18.3
  TOP w0.203: PR21.1 189.63,35.27 188.42,34.06 188.42,31.08 187.89,30.55 187.89,23.75 v4(187.65,23.51)
  BOTTOM w0.203: v4(187.65,23.51) 187.49,23.35 PR237.2
N18666070: length 9.6
  TOP w0.203: PR53.2 187.62,34.83 187.62,32.46 v4(186.22,31.05) 184.73,31.05 v4(184.07,30.39)
  BOTTOM w0.203: v4(184.07,30.39) 183.98,30.31 PR189.1 183.98,29.64 184.22,29.4 184.22,28.87 PR190.1
N18666111: length 0.8
  BOTTOM w0.203: PR248.1 170.45,21.86 170.63,21.67 PC182.2
N18666125: length 0.9
  BOTTOM w0.203: PR253.1 171.42,21.75 171.28,21.89 PC174.2
N18666311: length 2.2
  BOTTOM w0.198: PU12.39 181.4,22.06
  BOTTOM w0.203: PR258.2 182.13,20.61 181.81,20.92 v4(181.81,21.3) 181.81,21.64 181.4,22.06
N18666325: length 8.3
  IN1 w0.203: v4(184.41,17.71) 183.03,19.09 183.03,20.08 181.81,21.3 v4(181.07,21.3)
  BOTTOM w0.198: PU12.40 180.52,21.15
  BOTTOM w0.203: PR300.2 185.33,17.18 PR299.2 184.55,17.57 v4(184.41,17.71) ; 180.52,21.15 180.65,21.02 180.89,21.02 181.07,21.2 v4(181.07,21.3)
N18666410: length 1.5
  BOTTOM w0.203: PR281.1 177.47,18.22 v4(177.33,18.36) 177.01,18.68 PC197.1
N18666460: length 55.7
  TOP w0.203: PR28.1 151.22,46.88 156.32,41.77 162.46,41.77 165.08,39.14 165.08,21.09 167.03,19.14 168.34,19.14 170.84,16.64 173.92,16.64 174.31,17.03 175.47,17.03 177.12,15.39 180.12,15.39 180.69,15.96 v4(180.69,16.31)
  BOTTOM w0.203: v4(180.69,16.31) 180.51,16.49 180.03,16.49 179.64,16.88 PR293.2
N18666488: length 3.5
  BOTTOM w0.203: PR275.2 172.71,18.42 v4(172.84,18.3) 172.92,18.37 PC200.2 174.53,18.37 PC202.2 174.45,18.36 174.06,17.97 PR287.2
N18668050:
  vias: v4(155.98,51.11)
N18668099: length 2.1
  TOP w0.203: v4(155.82,56.5) 156.09,56.23 PR5.2 156.66,55.81 156.81,55.66 PU2.3
N18673106: length 2
  BOTTOM w0.117: PU13.12 189.86,22.95 189.79,22.88 v4(189.58,22.88) PC172.1
N18673108: length 1.4
  BOTTOM w0.117: PU13.10 190.45,22.14 190.34,22.04 PC176.1
N18673146: length 4.8
  BOTTOM w0.178: PU13.5 193.61,22.14 193.75,22.01 194.3,22.01 194.46,21.85 PC179.1
  BOTTOM w0.203: PC179.1 194.46,21.17 194.6,21.03 195.48,21.03 PR250.1 PR245.1
N18673154: length 5.4
  BOTTOM w0.178: v4(195.78,24.85) 195.96,24.67 PR230.2 PR238.2 195.96,22.93 195.88,22.85 194.58,22.85 194.46,22.97 PC170.1 194.21,23.28 193.87,22.95 PU13.3
N18673222: length 1.8
  TOP w0.117: PU1.12 82.27,58.14 82.65,58.51 82.65,58.76 82.93,59.04 PC2.1
N18673224: length 1.9
  TOP w0.117: PU1.10 83.07,58.59 v4(83.17,58.69) 83.26,58.78 83.45,58.78 83.66,58.99 PC3.1
N18673340: length 2.1
  TOP w0.117: PU3.12 93.23,49.82 v4(93.82,50.4) 94.08,50.66 PC29.1
N18673342: length 2.3
  TOP w0.117: PC35.1 94.26,49.95 93.95,49.64 93.95,49.41 v4(93.67,49.13) 93.56,49.02 PU3.10
N18677978: length 1.2
  TOP w0.117: PU6.12 89.22,42.91 89.15,42.84 PC60.1
N18677980: length 1.2
  TOP w0.117: PC59.1 88.29,42.66 88.42,42.8 PU6.10
N18731575: length 1.7
  BOTTOM w0.117: v4(61.36,17.58) 61.4,17.54 C353.2 61.4,16.8 R367.2
N18731881: length 12.3
  IN4 w0.071: v8(43.48,14.33) 43.86,14.33 45.13,13.06 46.83,13.06 48.2,11.69 49.03,11.69 49.21,11.51 49.42,11.51 49.63,11.72 49.63,12.33 49.93,12.64 50.84,12.64 51.92,11.56 v8(51.95,11.56)
  BOTTOM w0.076: U17.E6 52.31,11.91 v8(51.95,11.56)
  BOTTOM w0.117: v4(43.5,13.48) 43.39,13.58 R392.2
N18772040: length 16.2
  BOTTOM w0.117: PU10.4 76.24,28.12 75.69,28.66 75.26,28.66 73.3,30.62 73.3,32.26 72.36,33.2 72.36,33.67 v4(73,34.3) 73.34,34.64 PC117.1 78.25,34.64 78.67,34.22 78.67,34.2 78.77,34.1 PU9.3
N18772327: length 1.6
  BOTTOM w0.178: PU9.12 78.77,30.37 78.76,30.36 PC135.1
N18772329: length 1.6
  BOTTOM w0.117: PU9.10 79.57,30.27 79.57,30.27 v4(79.57,30.02) PC136.1
N18772365: length 3.2
  BOTTOM w0.178: PU9.5 79.57,33.92 79.83,34.18 PC119.1 PR170.1 80.88,34.64 v4(81.3,35.06)
N18961519: length 8.2
  TOP w0.117: T16.1 104.82,51.34 105.68,51.34 105.95,51.07 105.95,50.59 v1(106.01,50.53)
  IN1 w0.071: v1(110.84,48.31) 110.8,48.35 110.07,48.35 109.65,48.78 108.9,48.78 107.03,50.65 106.14,50.65 v1(106.01,50.53)
N18961543: length 10.7
  TOP w0.117: v1(101.24,36.16) 101.01,35.93 T32.1
  IN1 w0.06: v1(109.99,36.7) 109.99,36.67 109.26,35.95 109.25,35.95 109.13,35.83 107.85,35.83 107.49,36.2 107.44,36.2
  IN1 w0.071: v1(101.24,36.16) 101.4,36 102.31,36 102.75,36.45 102.9,36.45 103.32,36.02 103.83,36.02 104.01,36.2 104.64,36.2 104.87,35.97 105.21,35.97 105.43,36.2 107.44,36.2
N19176144: length 3.3
  TOP w0.064: 72.26,42.1 72.26,42.33 72.02,42.58 PU5.B12
  TOP w0.102: 72.26,42.1 72.64,41.72
  TOP w0.117: 72.64,41.72 v2(72.69,41.67)
  GND1 w0.102: v2(72.69,41.67) 72.69,41.39 v9(72.74,41.34)
  GND2 w0.127: v9(72.74,41.34) v8(72.74,40.96)
  BOTTOM w0.117: PR149.2 72.61,40.83 v8(72.74,40.96) 72.74,41.48 v4(72.89,41.64)
N19270898:
  vias: v4(207.64,24.11)
N19319857: length 6.4
  TOP w0.117: v1(116.94,49.49) 116.94,50.4 118.79,52.26 T11.1
  IN1 w0.071: v1(117.92,47.39) 117.84,47.39 117.57,47.67 117.57,48.86 v1(116.94,49.49)
N19319860: length 6.5
  TOP w0.117: v1(117.6,49.52) 117.6,50.46 119.73,52.59 T12.1
  IN1 w0.071: v1(117.6,49.52) 117.92,49.19 v1(117.92,47.89)
N19738745: length 5.4
  IN3 w0.094: v9(244.95,23.55) 247.59,23.55 v9(247.75,23.71)
  GND2 w0.127: v9(244.95,23.55) 245.05,23.45 v8(245.05,23.05) ; v8(247.75,24.04) v9(247.75,23.71)
  BOTTOM w0.117: U13.17 248.41,23.9 248.28,24.04 v8(247.75,24.04)
N19967862: length 3.2
  TOP w0.117: PU3.5 v4(89.73,49.02)
  BOTTOM w0.117: v4(89.73,49.02) 90.09,48.66 PC91.1 90.19,48.24 90.19,48.24 PR98.2 90.19,47.58 90.57,47.2 v4(90.75,47.2)
N19970589: length 4.1
  TOP w0.117: PU1.5 83.07,55.06 v4(83.5,54.63)
  BOTTOM w0.117: v4(85.29,53.68) 85.19,53.68 84.77,54.09 PR64.2 PR63.2 83.84,54.29 v4(83.5,54.63) 83.37,54.76 PC84.1
N19971810: length 1.2
  TOP w0.117: PU8.1 PR62.1
N19971812: length 4.1
  TOP w0.117: PR65.1 PU8.2 88.27,52.93 88.39,52.81 88.39,52.05 88.13,51.8 87.62,51.8 v4(87.37,51.54)
N19971816: length 11.9
  TOP w0.117: v4(88.23,54.24) 88.23,53.88 88.77,53.35 88.77,52.53 89.02,52.28 PU8.4 ; PU1.3 82.27,54.77 v4(82.3,54.74)
  IN4 w0.071: v4(88.23,54.24) 87.88,53.88 84.67,53.88 84.34,54.21 83.16,54.21 82.98,54.04 82.69,54.04 82.3,54.42 v4(82.3,54.74)
  BOTTOM w0.117: v4(81.93,54.11) 82.3,54.47 v4(82.3,54.74) 81.95,55.09 PC82.1
N19975647:
  vias: v4(183.64,7.91)
N19975655: length 6.1
  BOTTOM w0.117: PU16.3 180.98,7.84 181.23,7.59 PC232.1 181.23,6.75 181.19,6.71 PR320.2 181.19,5.82 180.84,5.47 v4(180.84,5.32) 181.22,4.93 PQ16.3 182.49,4.93 182.87,5.32 PR319.2
N19975671: length 35.5
  IN4 w0.381: v8(210.05,2.56) 207.81,2.56 207.47,2.23 190.53,2.23 189.38,3.39 188.06,3.39 187.85,3.18 184.04,3.18 183.85,2.99 v8(181.98,2.99)
  BOTTOM w0.381: v8(181.98,2.99) 181.98,3.54 183.48,5.03 PR319.1 183.48,5.85 183.13,6.2 PR311.1 183.75,6.32 184.02,6.59 PD4.1 ; v8(210.05,2.56) v4(209,2.56)
N19975677: length 3.7
  BOTTOM w0.203: PQ9.6 61.3,25.28 61.42,25.4 PR217.1 PR226.1 61.35,24.68 v4(61.1,24.43) 60.95,24.28 PR229.1
N19975679: length 1.7
  BOTTOM w0.117: v4(61.86,26.45) PR217.2
  BOTTOM w0.203: PR217.2 61.38,25.85 61.3,25.93 PQ9.5
N19975685: length 2.4
  BOTTOM w0.203: PQ9.1 58.31,25.28 v4(58.21,25.18) 58.17,25.14 PR220.1 PR214.1
N19975689: length 2.8
  BOTTOM w0.117: v4(59.2,24.28) PR229.2
  BOTTOM w0.203: PR229.2 59.78,24.89 59.85,24.96 59.85,25.7 59.63,25.93 PQ9.2
N19975719: length 8.9
  BOTTOM w0.203: PR223.1 55.53,24.93
  BOTTOM w0.305: 55.53,24.93 PR211.1 55.53,27.07 v4(54.84,27.76) 53.63,27.76 52.32,29.06 PQ8.3
N19975741: length 3.3
  BOTTOM w0.117: PU16.4 PR317.1 ; PR317.1 v4(180.98,13.91) ; PR317.1 PR315.1
N19975767:
  vias: v4(199.64,33.08)
N19975775:
  vias: v4(200.4,31.82)
N19975781: length 3.4
  BOTTOM w0.117: PU17.4 193.62,29.89 193.34,30.18 PR332.1 PR325.1 193.35,31.09 v4(193.59,30.84)
N19975811: length 11.5
  BOTTOM w0.117: PU17.3 197.91,29.89 198.24,29.56 PC237.1 199.09,29.56 199.38,29.86 PR334.1 PR331.2 200.56,29.86 200.65,29.95 200.65,30.59 201.16,31.1 201.8,31.1 202.56,31.86 v4(202.56,32.24) 202.56,32.37 201.92,33 200.91,33 199.76,34.14 PQ19.3
N20047552: length 4.2
  BOTTOM w0.117: PQ15.3 213.37,24.05 v4(213.02,24.4) 212.8,24.62 211.26,24.62 PR310.2
N20069111: length 3.8
  TOP w0.117: PU6.3 v4(89.22,46.55)
  BOTTOM w0.117: v4(89.22,46.55) 89.78,45.99 PC98.1 PR114.2 90.82,45.96 90.85,45.98 PR111.2 91.23,45.32 v4(91.26,45.3)
N20070147: length 5.5
  TOP w0.117: PU6.5 v4(88.42,46.55)
  BOTTOM w0.117: v4(85.41,46.13) PR112.1 PR113.1 86.28,45.34 86.38,45.24 PC96.1 87.64,45.24 88.36,45.96 88.36,46.5 v4(88.42,46.55)
N20234754: length 2.7
  BOTTOM w0.117: v4(192.96,37.45) 192.67,37.73 R199.1 R201.1 192.32,38.94 192.4,39.02 Q13.3
N20274642: length 11.4
  TOP w0.117: v1(99.71,44.36) 99.69,44.38 T21.1
  IN1 w0.06: v1(109.24,44.79) 108.58,44.79 108.4,44.97 108.1,44.97 108.02,44.89 107.77,44.89 107.33,44.45 105.89,44.45 105.76,44.58
  IN1 w0.071: 105.76,44.58 104.67,44.58 104.5,44.42 99.78,44.42 v1(99.71,44.36)
N20444921: length 1.9
  BOTTOM w0.117: U10.1 201.57,19.72 v4(201.7,19.84) 201.89,20.04 C300.1
N20445116: length 6.5
  IN4 w0.254: v8(201.42,24.62) 199.19,24.62 v8(198.54,25.28)
  BOTTOM w0.117: v4(197.78,24.44) 198.19,24.44 198.54,24.79 v8(198.54,25.28)
  BOTTOM w0.254: v8(201.42,24.62) 201.3,24.5 R283.1 C302.2
N20445118: length 3.7
  BOTTOM w0.117: U10.10 200.64,23.21 200.78,23.35 201.16,23.35 201.54,22.97 v4(201.8,22.97) R300.1 R299.1
N20445227: length 3.6
  BOTTOM w0.117: R299.2 203.33,20.95 203.19,20.81 v4(203.19,20.56) Q20.3
N20543374: length 2
  TOP w0.117: T33.1 81.23,35.79 U5.9
N20552780: length 2.6
  TOP w0.117: v4(163.32,42.7) 162.81,43.21 PR31.2 162.3,43.53 161.94,43.18 PU4.1
N20557258: length 4.9
  BOTTOM w0.117: Q16.2 43.53,28.46 43.45,28.39 42.88,28.39 ; 42.88,28.39 42.72,28.22 C288.2 R249.2 44.17,27.71 v4(44.42,27.46) ; 42.88,28.39 Q16.3
N20557273: length 3.3
  BOTTOM w0.117: v4(46.17,26.15) R251.2 R250.2 44.71,26.93 44.71,26.93 R249.1
N20557304: length 8.3
  BOTTOM w0.117: R240.2 34.22,28.57 34.68,28.11 SW2.2 35.07,28.74 35.17,28.84 37.82,28.84 37.92,28.74 SW2.1 38.5,28.11 v4(39.4,29.01) 39.78,29.01 39.87,28.91 Q17.3
N20610181: length 2.8
  BOTTOM w0.203: U19.39 244.19,7.07 243.45,6.33 243.45,5.96 243.11,5.61 C451.2
N20610208: length 3.1
  BOTTOM w0.117: C434.1 v4(254.1,8.23)
  BOTTOM w0.203: C434.1 252.69,8.23 252.65,8.27 U19.19
N20610240: length 1.5
  BOTTOM w0.117: U19.48 244.35,10.67 244.27,10.76 TP3.1
N20610439: length 2
  BOTTOM w0.117: U19.7 248.15,12.2 248.3,12.35 248.3,12.71 v4(248.28,12.73) 248.2,12.81 C371.1
N20610561: length 21.5
  IN1 w0.071: v4(255.52,15.93) 255.52,15.91 255.22,15.61 251.97,15.61 251.63,15.27 249.93,15.27 248.74,14.08 245.36,14.08 245.1,14.33 243.33,14.33 242.18,13.19 v4(239.77,13.19)
  BOTTOM w0.117: v4(237.84,12.96) D19.1 239.54,12.96 v4(239.77,13.19) 240,12.96 D20.1 ; v4(255.52,15.93) 255.52,16.16 255.05,16.63 R346.2
N20610622: length 8.7
  IN3 w0.203: v4(251.33,12.77) 251.35,12.74 251.35,8.65 v4(252.45,7.56)
  BOTTOM w0.203: v4(251.33,12.1) v4(251.33,12.77) R393.2 ; U19.20 252.13,7.87 v4(252.45,7.56)
N20615024: length 5
  BOTTOM w0.117: Q34.3 230.24,14.21 229.91,14.54 v4(229.91,15.35) 229.94,15.37 231.79,15.37 232.15,15.73 D35.1
N20616946: length 3.8
  BOTTOM w0.117: R433.1 222.24,11.02 R425.2 221.48,10.65 221.23,10.4 v4(221.23,9.89) 220.62,9.89 220.47,10.04 Q30.2
N20616966: length 19.8
  IN3 w0.508: v4(228.24,12.43) 228.24,13.83 226.48,15.6 224.64,15.6 221.09,12.05 219.53,12.05 v4(218.64,11.16)
  BOTTOM w0.508: v4(228.24,12.43) 227.83,12.43 227.45,12.05 227.45,11.41 ; v4(218.64,11.16) 218.69,11.16 219.32,11.79 Q30.3 218.46,12.02 217.77,12.71 v4(217.29,12.71) 217.04,12.45 R380.2
N20651243: length 3.2
  BOTTOM w0.117: PR305.1 PR307.2 175.89,3.66 176.48,4.25 v4(176.67,4.25) 176.71,4.29 PU15.4
N20651340: length 2.7
  BOTTOM w0.117: PR306.1 175,3.92 v4(175.38,4.3) 175.89,4.3 176.21,4.62 PU15.5
N20651346: length 2.3
  BOTTOM w0.117: PU15.6 176.21,9.45 176.27,9.51 PC161.1 PR235.1
N20690993:
  vias: v4(78.81,26.5)
N20691009: length 2.4
  BOTTOM w0.178: PR234.2 63.51,23.96 v4(63.6,24.04) 63.72,23.91 63.72,23.12 63.97,22.88 PU14.13
N20691013: length 34.5
  IN1 w0.508: v4(88.89,10.47) 88.89,12.05 88.03,12.91 79.73,12.91 78.79,13.86 65.63,13.86 64.28,15.2 64.28,16.17 64.82,16.7 v4(64.84,16.7)
  BOTTOM w0.203: v4(64.84,16.7) 64.71,16.7 PR292.2
  BOTTOM w0.508: PD7.1 90.21,7.37 89.43,8.16 89.43,9.71 v4(89.4,9.74) 89.4,9.96 v4(88.89,10.47)
N20691066: length 1.8
  BOTTOM w0.178: PU14.9 63.38,21.28 63.28,21.17 63.27,21.17 62.86,20.77 PR256.2
N20691132:
  vias: v4(78.99,14.71)
N20691268: length 2.3
  BOTTOM w0.203: T56.1 59.9,18.95 PC190.1 60.58,19.73 60.61,19.76 PR266.1
N20919304: length 12
  TOP w0.117: v4(175.9,57.56) 175.9,58.71 175.89,58.71 LED5.2
  BOTTOM w0.117: v4(175.9,57.56) 175.9,57.12 v4(176.56,56.46) 176.7,56.33 181.27,56.33 181.66,55.95 D7.1 182.19,55.02 182.19,53.81 181.89,53.52 R158.2
N20919308: length 12.6
  TOP w0.117: LED5.1 174.39,58.11 v4(175,57.51)
  BOTTOM w0.117: R157.2 180.38,53.52 180.13,53.76 180.13,55.04 D6.1 v4(178.53,55.55) 176.52,55.55 175,57.07 v4(175,57.51)
N21172005: length 14.5
  TOP w0.117: v1(101.16,45.6) 101.14,45.57 99.68,45.57 T24.1
  IN1 w0.06: 103.63,46.05 104.4,46.05 104.67,45.78 104.97,45.78 105.35,45.4 106.83,45.4 107.23,45.8 108.43,45.8 108.82,45.4 109.46,45.4 109.75,45.12 110.23,45.12 110.46,44.89 ; v11(110.05,43.24) 110.13,43.31 110.36,43.31 110.53,43.49 110.56,43.49 110.76,43.7 110.76,44.31
  IN1 w0.071: v1(101.16,45.6) 101.26,45.7 103.12,45.7 103.46,46.05 103.63,46.05 ; 110.46,44.89 110.76,44.58 110.76,44.31
N21172007: length 11.2
  TOP w0.117: T19.1 v1(100.17,44.18)
  IN1 w0.06: 104.69,44.3 104.72,44.33 107.46,44.33 107.52,44.39 108.71,44.39 108.94,44.16 109.13,44.16 109.39,43.9 109.39,43.67 109.5,43.56 109.82,43.56 v1(110.04,43.78)
  IN1 w0.071: v1(100.17,44.18) 100.27,44.28 104.67,44.28 104.69,44.3
N21220914: length 9
  BOTTOM w0.117: U20.G9 151.06,9.91 150.87,10.11 v4(150.87,10.42) 151.15,10.42 151.58,10.85 151.58,11.64 151.94,12 155.52,12 C381.2
N22084354: length 2
  TOP w0.117: Q2.2 99.54,56.83 99.89,56.47 v4(100.1,56.47) 100.12,56.45 R12.2
N22084365: length 2.1
  TOP w0.117: Q1.1 102.46,56.68 v4(102.28,56.5) 102.23,56.45 R12.1
N22351810: length 5.8
  TOP w0.117: LED6.2 185.9,59.21 186.4,58.71 v4(186.4,57.49)
  BOTTOM w0.117: R155.2 D13.1 185.58,56.22 v4(186.06,56.7) 186.4,57.05 v4(186.4,57.49)
N22351814: length 8
  TOP w0.117: v4(185.78,57.49) 185.78,58.77 184.4,60.15 LED6.1
  BOTTOM w0.117: R150.2 D8.1 183.67,56 v4(184.12,56.45) 184.32,56.65 185.41,56.65 185.78,57.02 v4(185.78,57.49)
N22588420: length 10.8
  TOP w0.117: T8.1 102.28,52.84 v1(103.35,51.77)
  IN1 w0.06: v1(109.48,46.96) 109.33,47.11 109.3,47.11 109.02,47.39 109.02,47.41 108.65,47.78 108.15,47.78
  IN1 w0.071: v1(103.35,51.77) 103.75,51.37 104.34,51.37 106.9,48.8 106.9,47.99 106.93,47.96 106.93,47.95 107.29,47.59 107.51,47.59 107.7,47.78 108.15,47.78
N22605730: length 10.5
  IN1 w0.06: 105.49,38.34 106.01,38.34 106.25,38.57 107.15,38.57 107.85,37.88 108.67,37.88 108.79,38 108.92,38 108.96,38.04 v1(110.04,38.04)
  IN1 w0.071: 105.49,38.34 104.23,38.34 104.11,38.22 103.62,38.22 103.32,38.52 102.33,38.52 101.87,38.06 100.96,38.06 100.57,37.66 v1(100.57,37.57)
N22608461: length 13.2
  TOP w0.117: v1(129.29,54.5) 129.29,55.37 T1.1
  IN1 w0.06: v1(123.78,47.89) 124,47.89 124.5,48.39 124.5,48.61 124.7,48.81 124.7,49.59 124.48,49.82 124.48,49.98
  IN1 w0.071: v1(129.29,54.5) 129.57,54.22 129.57,53.54 129.41,53.38 125.36,53.38 124.48,52.49 124.48,49.98
N22656295: length 1.7
  BOTTOM w0.117: R193.2 v4(138.4,41.58)
  BOTTOM w0.203: C194.1 137.6,40.73 R193.2
N22656325: length 1.6
  BOTTOM w0.117: R280.2 156.29,24.98 156.74,24.98 v4(156.94,24.77)
  BOTTOM w0.203: R280.2 156.28,25.37 156.21,25.43 C294.1
N22657187: length 1.8
  BOTTOM w0.117: v4(125.06,28.38) C290.1 124.63,27.48 124.6,27.45 R247.2
N22911521: length 2.9
  TOP w0.203: PU7.7 54.01,41.25 53.69,40.93 v4(52.78,40.93) 52.6,40.75 PR47.2
N22911634: length 70.5
  TOP w0.203: v1(61.49,33.48) 61.49,33.26 61.96,32.79 65.36,32.79 v4(66.54,31.6) 67.24,30.91 72.29,30.91 73.38,29.81 81.55,29.81 82.69,28.67 85.74,28.67 90.29,24.11 93.28,24.11 v4(95.3,26.14)
  IN1 w0.203: v1(61.49,33.48) 61.49,33.33 61.35,33.19 57.73,33.19 54.95,35.97 v4(54.71,35.97)
  BOTTOM w0.203: v4(95.3,26.14) 95.67,25.77 102.37,25.77 105.97,29.37 108.65,29.37 113.84,34.56 PR168.2 ; v4(54.71,35.97) PR167.2
N22911638: length 1.7
  BOTTOM w0.117: PR165.2 53.52,37.35 v4(53.87,37.7)
  BOTTOM w0.203: PR165.2 53.18,36.97 53.18,36.97 PR166.1
N22912068: length 1.3
  BOTTOM w0.117: PR141.1 53.41,41.6 v4(53.41,41.74)
N22925492:
  vias: v4(56.48,39.02)
N22926183:
  vias: v4(163.82,27.11)
N22926200: length 1.1
  BOTTOM w0.117: PC128.2 164.3,32.13 v4(164.59,32.42)
N22926247: length 3.6
  BOTTOM w0.117: PR195.2 158.69,28.43 v4(158.46,28.66)
  BOTTOM w0.203: PR195.2 159.13,27.9 159.73,27.3 160.57,27.3 160.86,27.01 PU11.7
N22955196: length 11.5
  IN1 w0.071: v1(66.17,35.33) 66.06,35.44 66.06,39.59 66.87,40.39 67.94,40.39 68.77,41.23 68.77,43.97 v1(68.02,44.73)
N22955327: length 9.3
  TOP w0.117: v1(75.13,49.41) 75.89,49.41 v4(76.04,49.56) 76.3,49.82 PR19.2
  IN1 w0.071: v1(75.13,49.41) 74.77,49.05 71.09,49.05 70.81,48.78 70.81,48.47 70.22,47.89 70.22,47.73 70.29,47.67 70.29,47.63 70.33,47.6 70.33,47.07 70.02,46.77 v1(70.02,46.23)
N22981973: length 1
  TOP w0.117: C2.2 101.23,57.92 100.81,57.49 R7.2
N22982990: length 1.6
  BOTTOM w0.117: R482.2 C458.2 54.3,4.33 v4(54.3,3.79)
N22983074: length 0.7
  TOP w0.117: R37.2 C4.2
N22983255: length 1.3
  BOTTOM w0.117: v4(108.86,32.29) R222.2 C269.2
N22983553: length 1.5
  BOTTOM w0.117: v4(96.31,29.14) 96.44,29.01 R236.2 C281.2
N23037532: length 0.5
  TOP w0.117: 44.82,54.46 v4(45.33,54.46)
N23038330: length 4.8
  BOTTOM w0.117: R230.2 87.82,29.29 v4(88.21,28.91) 87.98,28.68 87.49,28.68 86.99,28.18 86.99,27.74 87.15,27.58 U9.7
N23038357: length 4.7
  BOTTOM w0.254: U9.1 82.89,26.08 82.71,25.91 C295.1 82.71,24.69 82.57,24.54 R290.2 R291.2 83.64,24.41 84.07,23.98 v4(84.07,23.88) R505.2
N23086485: length 4.7
  BOTTOM w0.117: PU10.2 73.78,27.47 73.77,27.46 PR199.1 73.49,27.19 73.32,27.03 72.27,27.03 72.05,27.25 PR198.1 72.05,27.94 v4(72.51,28.4)
N23086491: length 4
  BOTTOM w0.117: PU10.1 74.32,26.82 74.11,26.6 v4(74.11,26.19) 73.86,26.19 73.68,26.37 PR210.1 73.47,26.12 73.4,26.05 72.14,26.05 72.08,26.11 PR209.1
N23207919: length 7.1
  IN1 w0.071: v3(66.25,42.75) 67.04,42.75 v1(67.49,43.2)
  IN2 w0.094: v3(66.25,42.75) 63.86,42.75 63.23,42.12 61.06,42.12 v3(60.93,41.99)
N23253258: length 6.8
  TOP w0.117: LED1.1 190,59.82 188.49,58.3 v4(188.49,56.4)
  BOTTOM w0.117: v4(189.3,56.4) v4(188.49,56.4) 188.44,56.34 D10.1 R152.2
N23253306: length 5.9
  TOP w0.117: LED3.1 188.71,59.36 188,58.66 188,57.06 v4(187.47,56.52)
  BOTTOM w0.117: v4(187.47,56.52) D9.1 R151.2
N23253357: length 11.3
  TOP w0.117: v4(199.66,58.71) 199.4,58.97 LED2.1
  BOTTOM w0.117: R154.2 D12.1 193.19,56.09 v4(193.47,56.37) 193.67,56.57 198.93,56.57 199.66,57.31 v4(199.66,58.71)
N23253403: length 13
  TOP w0.117: v4(199.08,58.71) 198.1,59.69 LED4.1
  BOTTOM w0.117: R153.2 D11.1 191.26,56.07 v4(191.72,56.53) 191.97,56.78 198.84,56.78 199.08,57.01 v4(199.08,58.71)
N24084686: length 3.4
  BOTTOM w0.117: v4(177.72,12.61) 177.64,12.53 PR494.1 PR492.1 176.27,12.81 176.65,13.19 176.65,13.57 176.54,13.68 PU19.1
N24084688: length 2.7
  BOTTOM w0.117: PR493.1 v4(175.51,13.06) 175.18,13.39 175.18,14.13 175.38,14.33 PU19.2
N24184609: length 3.7
  BOTTOM w0.117: v4(62.6,25.28) 62.6,25.76 63.01,26.17 R10952.1 R10951.1 63.7,27.24 63.42,27.52 D39.2
N24462115: length 3.6
  BOTTOM w0.117: v4(173.09,14.71) 173.56,14.25 C927.2 ; C927.2 173.91,13.85 174.13,13.63 R10934.2 ; C927.2 173.56,13.54 173.98,13.11 Q6062.2
N24462247: length 1.3
  BOTTOM w0.117: U39.9 173.93,6.43 174.05,6.55 174.05,6.65 174.36,6.97 R10930.1
N24462291: length 1.1
  BOTTOM w0.117: R659.2 174.11,7.09 173.85,6.83 U39.8
N24462338: length 2.1
  BOTTOM w0.117: TP88.1 171.52,4.99 171.52,6.28 171.67,6.43 U39.4
N24462340: length 1.8
  BOTTOM w0.117: U39.5 171.65,6.83 171.49,6.99 171.49,7.91 TP89.1
N24465197: length 2.7
  BOTTOM w0.117: Q6063.2 168.64,9.9 169.14,10.4 C725.1 R10941.2
N24583116: length 4.2
  BOTTOM w0.117: Q6068.3 202.56,14.59 202.18,14.97 202.18,15.6 202.43,15.86 v4(202.43,16.49) 202.43,17 202.18,17.25 R10963.2
N25078903: length 4.9
  BOTTOM w0.117: PR502.1 215.03,11.46 215.48,11.01 PR505.2 215.48,10.17 v4(215.77,9.89) ; PR502.1 215.03,12.15 214.38,12.79 PU20.4 ; PR502.1 PR499.2
N25078905: length 6.9
  BOTTOM w0.117: PR505.1 215.03,10.24 215.26,10.01 215.26,6.33 215.13,6.2 214.88,6.2 v4(214.5,5.82) 214.24,6.08 PQ22.2
N25078919: length 6.3
  IN4 w0.203: v8(212.75,10.78) 211.32,10.78 210.9,11.2 v8(209.66,11.2)
  BOTTOM w0.203: v4(209.16,10.9) 209.27,11.01 209.48,11.01 v8(209.66,11.2) 209.71,11.25 PQ20.4 ; PQ21.4 211.66,10.1 212.18,10.62 PR504.1 v8(212.75,10.78)
N25078922: length 5.3
  BOTTOM w0.117: PR503.1 213.2,10.17 v4(212.82,9.79) 212.82,8.77 213.35,8.24 214.75,8.24 214.89,8.38 PQ22.6
N25078926:
  vias: v4(210.69,10.78)
N25078939: length 2.5
  BOTTOM w0.117: PQ22.3 213.59,6.33 213.34,6.08 v4(212.85,6.08) 212.94,5.99 PR497.2
N25079793:
  vias: v4(202.69,12.25)
N25079799: length 4.1
  BOTTOM w0.117: PR507.1 PR516.1 195.03,10.49 195.32,10.21 195.7,10.21 196.08,10.59 PU21.4 v4(196.74,9.76)
N25079813: length 7.1
  BOTTOM w0.254: PD11.1 v4(206.5,10.61) 204.88,10.61 203.8,11.69 202.4,11.69 202.3,11.78 PR515.1 PR517.1
N25079814:
  vias: v4(202.81,9.76)
N25079824: length 6.8
  IN4 w0.071: v8(192.53,13.82) v8(194.91,13.82)
  BOTTOM w0.117: v8(192.53,13.82) 192.53,14.33 192.38,14.47 PQ23.6 191.24,14.47 191.13,14.59 191.13,14.66 190.95,14.84 PR512.1 190.72,14.69 190.27,14.23 PR514.1 189.78,14.08 v4(189.48,14.38)
N25079825: length 2
  BOTTOM w0.117: v4(190.24,13.37) 190.72,13.85 PR514.2 191,14.08 191.26,13.82 PQ23.5
N25079829: length 2.5
  BOTTOM w0.117: v4(195.5,14.21) 194.56,14.21 194.46,14.11 PR506.2 PQ23.2
N25079843: length 1.9
  BOTTOM w0.117: v4(194.46,15.33) PR509.1 194.18,14.59 194.06,14.47 PQ23.1
N25079845: length 2.2
  BOTTOM w0.117: PQ24.1 190.24,11.67 190.23,11.66 PR25.1 v4(188.98,11.66)
N25083539: length 2.3
  BOTTOM w0.117: U40.21 220.12,23.75 219.75,24.11 219.07,24.11 TP24.1
N25083553: length 5.9
  BOTTOM w0.117: TP38.1 229.61,19.16 229.31,19.46 226.64,19.46 226.05,20.05 U40.36
N25083555: length 5.4
  BOTTOM w0.117: TP39.1 229.63,19.64 226.84,19.64 225.93,20.55 U40.35
N25083703: length 4.5
  BOTTOM w0.117: R10982.1 R10983.1 C943.2 v4(226.89,19.03) 226.69,19.03 226.17,19.55 U40.37
N25083859: length 1.2
  BOTTOM w0.117: TP23.1 218.12,19.55 U40.14
N25084052: length 3.2
  BOTTOM w0.117: U40.33 v4(226.64,21.55) 227.99,21.55 C949.1
N25084056: length 4.8
  BOTTOM w0.305: U40.13 217.83,19.05 217.8,19.02 217.42,19.02
  BOTTOM w0.508: v4(215.64,18.19) 215.39,18.45 R10988.1 R10991.1 C944.2 217.42,19.02
N25084134: length 2
  BOTTOM w0.117: TP29.1 223.79,15.96 223.12,16.63 U40.4
N25084136: length 3.4
  BOTTOM w0.117: TP30.1 224.23,14.66 224.23,15.91 223.62,16.51 U40.3
N25084209: length 4.4
  BOTTOM w0.117: U40.5 222.62,16.62 223.39,15.85 223.39,13.8 TP28.1
N25084211: length 1.4
  BOTTOM w0.117: TP26.1 222.62,16.11 222.12,16.61 U40.6
N25086176: length 14
  BOTTOM w0.117: Q6069.3 186.68,4.93 v4(186.81,5.06) 187.32,5.57 187.83,5.57 188.03,5.77 189.96,5.77 190.24,5.49 190.24,4.99 190.92,4.3 191.76,4.3 192.02,4.05 192.02,3.29 192.18,3.12 193.32,3.12 193.87,2.58 196.46,2.58 196.72,2.83 R11000.2
N25086276: length 7
  IN3 w0.094: v4(202.18,5.37) 202.18,8.36 v4(202.43,8.62)
  BOTTOM w0.117: Q6070.4 202.07,8.26 v4(202.43,8.62) ; v4(202.18,5.37) 202.57,4.98 R11003.1 C959.2 202.57,2.94 v4(202.74,2.78)
N25086302: length 3.7
  BOTTOM w0.117: v4(197.12,2.75) 197.72,3.35 C955.1 197.72,3.88 196.72,4.88 196.72,5.06 196.86,5.2 U43.1
N25086480: length 3.7
  BOTTOM w0.117: R11006.1 R11004.1 v4(200.65,4.15) 201.03,4.53 201.03,5.06 200.89,5.2 U43.10
N25086597: length 11.7
  BOTTOM w0.117: R11006.2 198.49,2.51 v4(198.37,2.39) 198.32,2.34 193.85,2.34 193.25,2.94 192.1,2.94 191.84,3.21 191.84,3.92 191.66,4.1 190.87,4.1 190.04,4.93 Q6071.3
N25118502: length 7
  BOTTOM w0.117: PR519.1 v4(196.56,25.86) 196.51,25.92 194.51,25.92 194.12,26.3 194.12,27.41 193.98,27.56 PQ26.6 193.38,28.12 193.32,28.18 PR523.1 193.13,28.56 193.03,28.66 PR520.1
N25118504: length 2
  BOTTOM w0.117: PR520.2 192.53,27.69 v4(192.4,27.57) 192.4,27.54 193.03,26.91 PQ26.5
N25118512: length 1.7
  BOTTOM w0.117: PQ26.2 195.8,26.91 v4(195.88,26.98) 195.98,26.88 PR519.2
N25118541: length 2.1
  BOTTOM w0.117: PQ26.1 195.59,27.56 195.83,27.79 PR521.1 196.11,28.27 v4(195.83,28.56)
N25118545: length 2.9
  BOTTOM w0.117: PQ27.1 190.11,28.81 PR522.1 v4(190.99,28.44)
N25191021: length 1.9
  BOTTOM w0.117: PU22.3 185.39,9.74 185.13,9.48 185.13,9.46 184.96,9.28 PR525.2 PC251.1
N25201896: length 3.3
  BOTTOM w0.117: PU22.12 188.84,9.74 188.99,9.89 PC245.1 189.25,9.61 189.35,9.51 189.73,9.51 190.24,9 190.24,8.87 v4(190.49,8.62)
N25653242: length 1.3
  BOTTOM w0.117: R117.2 220.08,13.6 220.2,13.48 U16.3
N25653896: length 0.8
  BOTTOM w0.117: R121.2 218.69,26.12 218.73,26.16 U18.3
N187300890: length 5
  BOTTOM w0.076: 53.19,7.56 53.15,7.61 53.15,9.15 U17.K5
  BOTTOM w0.117: C456.1 53.74,4.91 v4(53.74,5.42) 53.38,5.77 53.38,6.13 53.11,6.41 53.11,6.87 53.19,6.96 53.19,7.56
N262237880:
  vias: v4(58.08,47.84)
N262255820: length 12.2
  IN1 w0.071: v1(67.02,45.73) 67.28,45.99 v3(67.28,45.99)
  IN2 w0.094: v3(67.28,45.99) 67.24,46.03 66.04,46.03 64.97,47.1 64.15,47.1 63.37,46.32 63.37,45.83 62.6,45.07 60.19,45.07 59.71,44.58 59.2,44.58 58.87,44.91 v3(58.87,46.44)

## Copper pours and planes (outline as drawn)
+1.5V on BOTTOM (solid shape): 240.71,6.92 240.71,5.96 240.71,5.95 239.25,5.95 239.16,6.05 239.16,6.9 239.29,7.03 240.61,7.03
+1.5V on BOTTOM (solid shape): 177.31,5.82 177.35,5.81 177.36,5.77 177.36,4.83 177.56,4.83 177.56,5.77 177.57,5.81 177.61,5.82 177.85,5.82 177.86,5.81 177.86,4.83 177.86,4.75 178,4.62 178.94,4.62 179.13,4.81 179.83,4.81 180.08,4.55 180.08,3.94 180.08,3.92 180.07,3.9 179.7,3.54 178.67,3.54 178.42,3.28 178.42,2.39 178.37,2.34 176.61,2.34 176.51,2.45 176.51,2.86 176.6,2.95 176.98,2.95 177.14,3.12 177.14,3.69 177.02,3.81 177.02,4.59 177.06,4.62 177.06,5.77 177.07,5.81 177.11,5.82
+3.3V_TYPEC_MUX on TOP (solid shape): outline of 1360 points within 229.48,17.38 254.18,29.45
+3.3V_TYPEC_MUX on BOTTOM (solid shape): 233.93,19.16 233.93,17.25 233.67,17 232.4,17 232.15,17.25 232.15,19.16 232.28,19.29 233.8,19.29
+3.3V_TYPEC_MUX on BOTTOM (solid shape): 242.16,19.84 242.16,18.47 242.01,18.31 241.19,18.31 241.19,19.69 241.47,19.97 242.04,19.97
+3.3V_TYPEC_MUX on BOTTOM (solid shape): 233.42,27.29 233.42,26.14 233.29,26.02 232.66,26.02 231.64,27.03 231.13,27.03 231.01,27.16 231.01,28.43 231.13,28.56 232.15,28.56
+3.3V_TYPEC_MUX on BOTTOM (solid shape): 255.01,29.57 255.01,27.67 255.26,27.41 255.26,26.52 255.14,26.4 254.5,26.4 254.25,26.14 253.74,26.14 252.98,25.38 252.85,25.38 252.72,25.51 252.72,26.27 253.41,26.95 253.41,29.75 253.61,29.95 254.63,29.95
+3.3V_TYPEC_MUX on BOTTOM (solid shape): 246.79,27.54 248.28,27.54 248.41,27.41 248.41,27.03 248.79,26.65 249.04,26.65 249.68,26.02 249.68,25.51 249.93,25.25 249.93,25.13 249.8,25 248.91,25 248.79,25.13 248.79,25.64 247.77,26.65 245.74,26.65 245.61,26.78 245.61,27.59 245.74,27.72 246.61,27.72
+3V on TOP (solid shape): 194,34.32 194,30.82 193.14,29.95 190.75,29.95 190.49,30.21 190.49,34.17 190.7,34.37 193.95,34.37
+3V on TOP (solid shape): 84.04,36.92 84.04,35.8 84.02,35.78 83.71,35.78 83.66,35.83 83.66,36.08 83.56,36.18 81.99,36.18 81.88,36.29 81.88,36.57 81.46,36.99 80.97,36.99 80.86,37.11 80.86,37.61 80.98,37.74 83.23,37.74
+3V on TOP (solid shape): 41.31,36.94 41.31,35.57 41.57,35.3 41.57,32.07 41.37,31.87 38.55,31.87 38.45,31.97 38.45,33.3 39.64,33.3 39.98,33.3 39.98,33.49 39.89,33.49 39.89,33.5 38.49,33.5 38.46,33.52 38.45,33.55 38.45,33.75 38.5,33.8 40.08,33.8 40.46,34.18 40.46,36.74 40.46,36.74 40.46,36.98 40.54,37.07 41.18,37.07
+3V on TOP (solid shape): 40.81,54.87 40.81,53.45 40.23,52.87 40.23,50.26 40.06,50.09 39.07,50.09 38.9,50.03 38.14,50.03 38.02,50.15 38.02,50.3 39.98,50.3 39.98,50.5 38.49,50.5 38.49,50.3 38.02,50.3 38.02,50.8 39.98,50.8 39.98,51 38.49,51 38.49,50.8 38.02,50.8 38.02,51.93 38.04,52.02 38.08,52.18 38.1,52.28 38.42,52.61 38.42,52.91 38.44,52.96 38.45,53.05 38.46,53.15 38.45,53.24 38.44,53.33 38.42,53.38 38.42,54.58 38.89,55.05 40.63,55.05
+3V on TOP (solid shape): 86.51,33.89 86.52,33.86 86.52,33.83 86.77,33.48 87.14,33.69 87.21,33.76 87.31,33.73 87.57,33.47 87.57,31.41 87.31,31.15 83.95,31.15 83.74,31.35 83.74,33.77 83.76,33.8 84.02,33.8 84.04,33.77 84.04,32.5 84.5,32.04 84.86,32.04 85.39,32.58 85.39,33.82 85.46,33.89
+3V on BOTTOM (solid shape): 9.51,18.31 9.51,16.38 9.38,16.25 6.93,16.25 6.77,16.42 6.77,18.14 7.03,18.4 9.42,18.4
+3V on BOTTOM (solid shape): 8.2,12.25 8.2,11.08 8.07,10.95 5.33,10.95 5.05,11.23 5.05,12.38 8.07,12.38
+3V on BOTTOM (solid shape): 192.45,32.53 192.45,30.26 192.31,30.11 192.05,30.11 191.8,30.36 191.8,30.56 191.61,30.76 191.16,30.76 191.01,30.91 191.01,32.22 191.45,32.66 192.32,32.66
+3V on BOTTOM (solid shape): 132.87,5.06 139.33,5.06 139.33,4.99 139.87,4.99 139.87,5.06 142.23,5.06 142.39,4.91 142.39,2.37 142.22,2.2 131.87,2.2 130.04,4.03 130.03,4.03 129.97,4.1 99.16,4.1 98.85,4.41 98.85,6.13 99.34,6.62 131.31,6.62
+3V on BOTTOM (solid shape): 198.88,47.76 198.88,47.3 199.05,47.12 199.66,47.12 199.99,46.79 200.91,46.79 201.11,46.59 201.11,45.8 200.81,45.5 199.71,45.5 199.59,45.63 198.32,45.63 198.16,45.78 198.16,47.78 198.32,47.94 198.7,47.94
+3V on BOTTOM (solid shape): 95.97,33.9 95.97,32.29 95.21,31.54 91.74,31.54 91.52,31.76 91.52,31.94 93.65,34.06 94.14,34.06 94.34,33.86 94.42,33.86 94.51,33.85 94.59,33.86 94.78,33.86 95.1,34.18 95.69,34.18
+3V on BOTTOM (solid shape): 191.7,26.45 192.04,26.45 192.69,25.8 193.24,25.8 193.75,25.29 193.75,24.89 193.61,24.75 192.39,24.75 192.21,24.93 192.21,25.17 192.13,25.26 191.59,25.26 191.17,25.68 191.17,25.89 190.96,25.89 190.95,25.9 190.33,25.9 190.23,25.99 190.23,26.89 190.28,26.94 191.21,26.94
+3V on IN1 (solid shape): outline of 522 points within 85.87,4.54 102.41,34.21
+3V on IN1 (solid shape): outline of 1681 points within 133.14,2.17 196.35,32.75
+3V on SVCC (solid shape): 197.55,48.92 197.56,48.9 197.86,48.68 198.16,48.9 198.17,48.92 198.2,48.94 198.79,48.94 199.13,48.59 199.13,46.32 194.88,42.07 194.85,42.05 194.82,42.06 194.41,42.02 194.37,41.62 194.38,41.58 194.37,41.55 193.41,40.6 193.41,33.16 193.4,33.09 193.41,33.06 193.41,29.17 193.06,28.81 191.41,28.81 191.05,29.17 191.05,40.57 191.05,40.58 191.05,48.7 191.29,48.94 197.52,48.94
+3V on IN3 (solid shape): 100.65,45.78 100.65,44.76 99.77,43.87 97.05,43.87 96.92,44 96.92,44.45 98.32,45.85 100.58,45.85
+3V on IN3 (solid shape): outline of 3889 points within 5.79,11.08 103.88,53.13
+3V_EC_VCC on IN4 (solid shape): 53.4,10.08 53.4,9.91 53.35,9.82 53.24,9.83 52.94,9.62 53.3,9.58 53.32,9.61 53.4,9.61 53.4,9.55 53.49,9.46 53.49,9.08 53.34,8.93 53.34,8.42 53.28,8.36 53.28,8.08 53.27,8.07 53.2,7.94 53.23,7.79 53.28,7.75 53.35,7.72 53.38,7.72 53.38,6.81 53.26,6.56 53.38,6.31 53.38,6.13 53.18,5.93 52.47,5.93 52.37,6.03 52.37,6.34 52.39,6.41 52.59,6.51 52.64,6.65 52.66,6.72 52.73,6.76 52.89,6.9 52.82,7.1 52.79,7.17 52.82,7.25 52.84,7.27 52.86,7.27 52.92,7.26 52.98,7.28 53.09,7.49 52.9,7.65 52.83,7.68 52.8,7.75 52.8,9.76 52.67,9.89 52.67,9.99 52.78,10.09 53.38,10.09
+3V_LCDVCC on BOTTOM (solid shape): 80.07,30.62 80.27,30.62 80.27,31.49 80.94,31.49 81,31.44 81,30.67 81.07,30.6 82.19,30.6 82.29,30.5 82.29,29.35 82.21,29.28 79.98,29.28 79.85,29.4 79.85,29.76 79.95,30.02 79.85,30.28 79.85,30.62 79.87,30.62 79.87,30.69 79.87,31.35 79.87,31.42 79.93,31.49 80.07,31.49
+3V_PANEL on BOTTOM (solid shape): 18.25,12.61 18.25,10.89 18.12,10.76 16.73,10.76 16.55,10.94 16.55,11.83 16.67,11.95 17.29,11.95 17.35,12.02 17.35,12.58 17.49,12.72 18.14,12.72
+3V_PANEL on BOTTOM (solid shape): outline of 157 points within 80.16,30.85 84.45,39
+3V_PANEL on IN1 (solid shape): 17.74,12.03 17.74,10.87 17.54,10.67 16.07,10.67 15.91,10.83 15.91,11.69 16.02,11.8 16.45,11.8 16.76,12.11 17.67,12.11
+3V_PANEL on IN1 (solid shape): 81.07,38.5 81.07,37.05 80.74,36.71 80.7,36.7 80.67,36.71 80.3,36.74 80.15,36.41 80.12,36.32 80.05,36.29 79.24,36.29 79.12,36.41 79.12,38.45 79.27,38.6 80.97,38.6
+3V_PANEL on IN1 (solid shape): outline of 98 points within 57.93,31.13 65.4,32.67
+3V_PANEL_CONN on BOTTOM (solid shape): 22.7,14.66 22.7,14.12 22.61,14.03 22.61,13.35 22.46,13.2 22.11,13.2 21.54,12.64 21.54,12.19 21.45,12.1 21.41,12.1 21.39,12.12 20.86,12.12 20.75,12.02 20.61,12.02 20.5,12.12 19.97,12.12 19.86,12.02 19.8,12.02 19.57,11.79 19.57,11.1 19.41,10.94 18.93,10.94 18.65,11.21 18.65,12.64 18.76,12.75 20.95,12.75 21.49,13.29 21.49,13.41 22.4,13.41 22.4,14.29 22.2,14.29 22.2,13.41 21.9,13.41 21.9,14.29 21.7,14.29 21.7,13.41 21.49,13.41 21.49,14.03 21.4,14.12 21.4,14.63 21.51,14.74 22.62,14.74
+3V_POA_R on BOTTOM (solid shape): 172.59,12.05 172.59,11.03 171.14,11.03 170.89,10.78 170.89,8.03 170.33,7.48 169.36,7.48 169.21,7.62 169.21,8.57 169.27,8.62 170.07,8.62 170.25,8.8 170.25,11.62 170.28,11.64 170.81,11.64 170.94,11.77 170.94,12.02 171.01,12.1 172.54,12.1
+3V_S2 on BOTTOM (solid shape): 190.23,25.69 190.98,25.69 191.38,25.29 191.38,23.65 190.52,23.65 190.52,23.44 191.38,23.44 191.38,23.31 191.33,23.26 189.55,23.26 189.48,23.33 189.48,25.31 189.52,25.32 189.71,25.42 189.8,25.62 189.83,25.69 189.9,25.72 190.23,25.72
+3V_SPI on TOP (solid shape): 42.95,44.51 42.95,44.03 42.36,43.44 42.13,43.44 41.95,43.26 41.95,43.06 41.75,42.86 41.32,42.86 41.24,42.9 41.22,42.98 41.14,43.29 40.84,43.37 40.75,43.39 40.71,43.47 40.71,44.69 40.79,44.76 42.69,44.76
+3V_SPI on BOTTOM (solid shape): 43.53,45.35 43.53,43.24 43.81,42.96 45.99,42.96 46.12,42.83 46.12,42.27 45.89,42.04 43.68,42.04 42.57,43.16 42.57,43.18 41.98,43.77 41.98,45.3 42.11,45.42 43.45,45.42
+3V_TP_CLICK on BOTTOM (solid shape): 127.11,9.85 127.11,9.47 127.26,9.33 127.46,9.33 127.79,9.66 129.14,9.66 129.18,9.62 129.18,9.46 129.12,9.4 127.99,9.4 127.67,9.08 127.26,9.08 127.11,8.94 127.11,8.54 126.97,8.39 126.78,8.39 126.65,8.52 126.65,9.87 126.76,9.98 126.98,9.98
+3V_TS on BOTTOM (solid shape): 201.76,51.42 201.76,48.18 200.88,47.3 200.15,47.3 199.99,47.45 199.99,48.11 200.07,48.19 200.07,50.28 200.34,50.56 200.34,51.41 200.34,51.41 200.34,51.61 200.39,51.67 201.52,51.67
+3V_WLAN on TOP (solid shape): 93.9,52.62 93.9,50.82 93.87,50.75 93.8,50.72 93.56,50.59 93.51,50.31 93.51,50.28 93.5,50.26 93.34,50.1 93.09,50.1 93.09,50.12 92.36,50.12 92.27,50.21 92.27,50.27 92.29,50.3 92.32,50.32 93.09,50.32 93.09,50.52 92.32,50.52 92.29,50.53 92.27,50.57 92.27,51.94 92.19,52.02 92.19,52.62 92.35,52.78 93.74,52.78
+5V on BOTTOM (solid shape): 225.67,14.08 227.2,14.08 227.32,13.95 227.32,12.68 227.07,12.43 226.72,12.43 224.75,12.43 224.37,12.05 223.36,12.05 223.23,11.92 222.5,11.92 222.37,12.05 222.37,12.81 222.5,12.94 223.64,12.94 224.15,13.44 224.15,13.96 224.32,14.13 225.63,14.13
+5V on BOTTOM (solid shape): 236.04,7.03 236.04,4.21 234.81,4.21 234.13,3.53 234.13,3.18 234.35,2.96 234.67,2.96 234.84,3.13 236.02,3.13 236.14,3 236.14,2.29 236.02,2.16 233.78,2.16 233.6,2.35 233.6,4.74 233.63,4.76 233.91,4.76 234.49,5.34 234.49,6.26 235.05,6.82 235.05,7 235.1,7.05 236.01,7.05
+5V on BOTTOM (solid shape): 191.65,19.05 191.69,19.03 191.7,19 191.7,18.65 192.02,18.33 192.34,18.65 192.34,19.03 192.35,19.05 192.96,19.05 193.12,18.89 193.12,18.51 193.11,18.5 193.1,18.4 193.11,18.3 193.12,18.29 193.12,18.05 192.47,17.4 190.64,17.4 190.36,17.68 190.36,18.94 190.47,19.05
+5V on IN4 (solid shape): outline of 2240 points within 191.57,3.18 236.05,19.03
+5V_PVDD on BOTTOM (solid shape): 240.43,8.65 240.86,8.22 240.86,7.98 241.24,7.6 241.24,7.4 241.16,7.31 240.8,7.31 240.79,7.31 239.64,7.31 239.52,7.43 239.52,8.6 239.58,8.66 240.43,8.66
+5V_PVDD on BOTTOM (solid shape): 233.94,7.83 233.94,7.82 234.01,7.72 234.11,7.65 234.12,7.65 234.3,7.47 234.63,7.47 234.89,7.2 234.89,6.8 234.83,6.73 233.18,6.73 233.04,6.87 233.04,7.99 233.14,8.09 233.67,8.09
+5V_PVDD on IN3 (solid shape): outline of 173 points within 233.04,6.75 244.11,11.88
+5V_S2 on BOTTOM (solid shape): 191.36,21.81 191.36,21.7 191.34,21.66 191.31,21.65 190.52,21.65 190.52,21.44 191.31,21.44 191.34,21.43 191.36,21.39 191.36,19.42 191.23,19.29 190.32,19.29 190.1,19.51 189.63,19.51 189.45,19.69 189.45,21.68 189.5,21.73 189.73,21.73 189.83,21.83 191.33,21.83
+5V_USBP0_L on BOTTOM (solid shape): 200.79,25.77 200.79,24.91 199.78,23.9 199.78,22.14 199.73,22.09 198.57,22.09 198.41,22.25 199.5,22.25 199.5,23.09 199.28,23.09 199.28,22.25 199,22.25 199,23.09 198.78,23.09 198.78,22.25 198.41,22.25 197.44,23.21 197.05,23.21 196.95,23.31 196.95,24 197.06,24.11 198.27,24.11 198.95,24.79 198.95,25.67 199.06,25.79 200.77,25.79
+5V_USBP1_L on BOTTOM (solid shape): 201.51,9.22 201.51,7.62 201.63,7.5 202.61,7.5 202.66,7.45 202.66,5.96 202.48,5.78 201.34,5.78 201.09,6.03 200.8,6.03 200.77,6.07 199.93,6.07 199.89,6.08 199.88,6.12 199.88,6.29 199.89,6.33 199.93,6.34 200.77,6.34 200.77,6.57 199.93,6.57 199.89,6.58 199.88,6.62 199.88,6.79 199.89,6.83 199.93,6.84 200.77,6.84 200.77,7.07 199.93,7.07 199.89,7.08 199.88,7.12 199.88,8.15 199.36,8.67 199.36,9.27 199.49,9.39 201.33,9.39
+5VA on BOTTOM (solid shape): 237.79,7.08 237.79,5.58 238.37,4.99 238.37,4.59 238.42,4.54 238.42,4.3 238.72,4 241.35,4 241.68,4.33 241.68,4.71 241.71,4.74 241.78,4.74 241.86,4.7 241.88,4.62 241.87,4.36 241.97,4.13 241.98,4.12 241.98,3.37 241.84,3.23 241.49,3.23 241.31,3.41 239.49,3.41 239.39,3.32 238.7,3.32 238.55,3.47 238.43,3.47 238.4,3.5 237.08,3.5 236.72,3.85 236.72,7.05 236.85,7.18 237.69,7.18
+V3.3S_SEN on BOTTOM (solid shape): 144.46,4.66 144.46,3.92 144.33,3.8 144.33,3.38 144.46,3.25 144.46,2.82 144.16,2.52 143.1,2.52 142.77,2.85 142.77,4.6 142.87,4.71 144.42,4.71
+V3.3S_SEN on BOTTOM (solid shape): 151.53,7.85 151.6,7.82 151.63,7.76 151.91,7.38 152.38,7.48 152.46,7.56 152.52,7.56 152.7,7.38 152.7,6.64 152.59,6.53 152.53,6.53 152.42,6.52 152.37,6.47 152.37,6.43 152.34,6.38 152.32,6.29 152.34,6.19 152.37,6.14 152.42,6.09 152.47,6.06 152.56,6.05 152.64,6.06 152.7,6.06 152.71,6.02 152.78,5.9 152.88,5.82 152.97,5.78 153.06,5.77 153.07,5.77 153.11,5.76 153.12,5.72 153.12,5.61 153.2,5.53 153.13,5.37 153.14,5.19 153.13,5.14 153.1,5.09 153.04,5.04 151.1,5.04 150.9,5.24 150.9,5.96 151,6.06 151.49,6.06 151.49,6.06 151.74,6.13 151.79,6.39 151.79,6.69 151.81,6.79 151.79,6.89 151.79,6.92 151.76,6.92 151.73,6.96 151.68,7 151.35,7.33 151.35,7.76 151.39,7.84 151.48,7.86
+V3.3S_SEN on IN3 (solid shape): outline of 96 points within 142.77,4.02 157.55,6.28
+V3.3S_SEN on GND2 (solid shape): 146.96,7.35 146.96,6.74 146.76,6.54 145.94,6.54 145.84,6.64 145.84,7.96 145.94,8.06 146.25,8.06
+VCC_PRIM_SRC on TOP (solid shape): 164.73,33.95 164.73,31.58 164.54,31.39 163.19,31.39 162.83,31.69 162.47,31.39 159.7,31.39 159.21,31.88 159.21,32.93 159.39,33.1 160.92,33.1 161.81,32.21 163.48,32.21 163.57,32.2 163.66,32.21 163.84,32.21 164.06,32.43 164.06,32.48 164.27,32.69 164.27,33.51 164.37,33.6 164.37,34.02 164.38,34.03 164.65,34.03
+VCC_PRIM_SRC on BOTTOM (solid shape): 161.8,33.4 161.8,33.06 162.02,32.83 162.02,30.54 161.88,30.39 158.3,30.39 158.1,30.59 158.1,31.65 158.51,32.06 159.17,32.06 159.57,32.45 159.57,33.07 159.91,33.42 161.78,33.42
+VCC_VCCIO_SRC on TOP (solid shape): 52.7,39.86 52.7,37.83 53.21,37.32 53.97,37.32 54.22,37.07 54.22,36.43 53.97,36.18 50.67,36.18 50.54,36.3 50.54,37.9 50.67,38.03 50.67,39.86 50.92,40.11 52.44,40.11
+VCC_VCCIO_SRC on BOTTOM (solid shape): 52.3,37.64 52.3,35.89 52.13,35.72 51.73,35.72 51.16,36.29 51.16,37.71 51.35,37.9 52.04,37.9
+VCCAPLL_1P0 on BOTTOM (solid shape): 105.48,48.72 105.48,48.45 105.61,48.32 105.61,48.32 106.83,47.1 106.83,46.44 106.67,46.29 104.13,46.29 104.03,46.39 104.03,48.01 104.82,48.8 105.4,48.8
+VCCIO_S2 on BOTTOM (solid shape): 78.02,31.44 78.05,31.42 78.07,31.39 78.07,30.62 78.27,30.62 78.27,31.39 78.28,31.42 78.32,31.44 78.4,31.44 78.47,31.37 78.47,30.69 78.47,30.62 78.48,30.62 78.48,29.48 78.25,29.25 75.93,29.25 75.71,29.47 75.71,31.38 75.76,31.44
+VCCPAZIO on BOTTOM (solid shape): 113.62,38.27 113.62,37.95 113.74,37.83 113.74,36.92 113.45,36.62 113.45,35.58 113.2,35.33 112.71,35.33 112.58,35.19 112.58,34.08 111.78,33.29 110.55,33.29 110.52,33.32 109.92,33.32 109.82,33.42 109.82,34.71 109.98,34.87 110.44,34.87 110.84,34.48 111.48,34.48 111.68,34.68 111.68,35.56 112.74,36.61 112.74,37.03 113.26,37.56 113.26,38.28 113.32,38.34 113.56,38.34
+VCCPSPI on BOTTOM (solid shape): 48.36,46.64 48.36,42.7 47.87,42.22 46.55,42.22 46.48,42.3 46.48,45.52 45.61,46.39 43.73,46.39 43.58,46.54 43.58,47.2 43.86,47.48 47.52,47.48
+VCCSFR on TOP (solid shape): 95.93,48.52 95.93,48.27 96.89,47.3 96.89,44.97 96.7,44.77 96.09,44.77 96.09,44.77 96.02,44.77 95.64,44.39 95.64,44.32 94.51,43.19 94.51,41.62 94.33,41.44 92.07,41.44 91.94,41.57 91.94,44.29 92.02,44.36 93.39,44.36 93.39,44.38 94.28,45.27 94.86,45.27 95.09,45.5 95.09,45.94 94.91,46.12 94.91,48.63 94.99,48.71 95.74,48.71
+VCCSFR on BOTTOM (solid shape): 117.72,48.17 117.72,47.61 117.66,47.54 117.39,47.54 117.38,47.53 117.09,47.53 116.53,46.97 115.16,46.97 114.88,47.25 114.88,48.11 114.98,48.22 117.67,48.22
+VCCSFR on BOTTOM (solid shape): 98.47,53.75 98.47,50.27 96.84,48.65 96.84,43.03 95.85,42.04 93.44,42.04 93.16,42.32 93.16,42.86 93.36,43.06 94.18,43.06 95.5,44.38 95.5,49.03 97,50.53 97,53.63 97.23,53.86 98.37,53.86
+VCCSFR on IN4 (solid shape): 98.5,54.8 98.5,52.56 98.36,52.43 97.28,52.43 97.15,52.56 97.15,54.87 97.35,55.07 98.22,55.07
+VCCSFR on IN4 (solid shape): 116.12,50.48 116.12,46.16 116.07,46.11 115.92,46.11 115.01,47.02 115.01,48.72 115.12,48.88 115.05,49.05 115.12,49.21 115.05,49.36 115.12,49.54 115.01,49.69 115.01,50.58 115.16,50.73 115.87,50.73
+VCCST_CPU on TOP (solid shape): 89.67,44.01 89.7,43.99 89.72,43.96 89.72,43.19 89.92,43.19 89.92,43.96 89.93,43.99 89.97,44.01 90.16,44.01 90.27,43.91 90.27,43.35 90.44,43.17 91.38,43.17 91.56,42.99 91.56,42.13 91.46,42.03 90.57,42.03 90.32,42.28 89.63,42.28 89.5,42.41 89.5,43.19 89.52,43.19 89.52,43.95 89.58,44.01
+VCCST_CPU on BOTTOM (solid shape): 186.25,20.48 186.25,18.25 185.87,17.87 185.49,17.87 185.39,17.97 185.39,20.61 185.44,20.66 186.07,20.66
+VCCST_CPU on BOTTOM (solid shape): 114.87,47.16 114.87,46.43 114.61,46.43 114.58,46.39 114.55,46.38 114.51,46.37 114.48,46.34 114.46,46.31 114.44,46.27 114.43,46.24 114.43,46.2 114.44,46.16 114.45,46.12 114.47,46.09 114.5,46.06 114.53,46.04 114.57,46.03 114.61,46.02 114.65,46.02 114.68,46.03 114.72,46.04 114.75,46.07 114.78,46.1 114.87,46.1 114.87,45.99 114.99,45.87 115.35,45.87 115.41,45.8 115.41,45.04 115.34,44.97 114.37,44.97 113.78,45.55 113.79,45.6 113.78,45.65 113.77,45.68 113.77,45.77 113.76,45.81 113.75,45.85 113.72,45.89 113.69,45.92 113.65,45.95 113.61,45.97 113.57,45.97 113.55,45.97 113.36,45.97 113.06,46.28 113.06,47.12 113.9,47.12 113.9,47.09 113.91,47.05 113.93,47.02 113.93,46.74 114.26,46.74 114.26,47.03 114.27,47.06 114.28,47.1 114.28,47.14 114.27,47.18 114.26,47.22 114.26,47.25 114.23,47.25 114.22,47.27 114.19,47.29 114.15,47.31 114.11,47.31 114.07,47.31 114.03,47.31 113.99,47.29 113.96,47.27 113.95,47.25 113.93,47.25 113.93,47.23 113.91,47.2 113.9,47.16 113.9,47.12 113.06,47.12 113.06,47.28 113.21,47.43 114.6,47.43
+VCCST_CPU on BOTTOM (solid shape): outline of 129 points within 89.38,40.19 103.7,52.43
+VCCST_CPU on IN4 (solid shape): outline of 300 points within 100.15,45.07 115.69,55.25
+VCCST_S2 on TOP (solid shape): 94.56,49.44 94.56,47.61 94.43,47.49 93.53,47.49 93.16,47.11 92.63,47.11 92.3,47.44 92.3,48.27 92.31,48.3 92.35,48.32 93.09,48.32 93.09,48.52 92.35,48.52 92.31,48.53 92.3,48.57 92.3,48.66 92.36,48.72 93.81,48.72 94.22,49.13 94.22,49.41 94.3,49.49 94.51,49.49
+VCCSTG on BOTTOM (solid shape): 109.62,53.6 109.62,52.17 109.51,52.05 108.93,52.05 108.6,52.38 108.6,53.68 108.68,53.75 109.47,53.75
+VCCSTG on BOTTOM (solid shape): 75.83,33.97 75.83,33.73 75.77,33.54 75.83,33.36 75.83,33.35 76.63,32.56 76.63,31.87 76.55,31.79 74.34,31.79 74.21,31.92 74.21,34.03 74.34,34.16 75.65,34.16
+VCCSTG on IN3 (solid shape): 109.72,53.33 109.72,52.52 109.25,52.05 108.75,52.05 108.2,52.59 108.2,52.98 108.76,53.53 109.52,53.53
+VCCSTG on IN4 (solid shape): outline of 127 points within 107.56,43.9 115.41,52.97
+VDDD_SUPPLY on BOTTOM (solid shape): 228.3,25.83 228.3,24.9 227.97,24.57 227.97,22.42 227.98,22.42 227.98,21.94 227.86,21.82 227.41,21.82 227.33,21.91 224.98,21.91 224.94,21.96 224.94,22.15 224.96,22.19 224.99,22.2 225.97,22.2 225.97,22.4 224.99,22.4 224.96,22.41 224.94,22.45 224.94,22.73 226.46,24.25 226.46,25.65 226.66,25.85 226.68,25.85 226.83,25.9 226.96,26.01 226.97,26.03 227,26.03 228.09,26.03
+VDDD_SUPPLY on IN4 (solid shape): outline of 542 points within 222.46,14.51 229.97,26.78
+VIN on TOP (solid shape): 75.92,37.38 75.92,36.77 75.14,35.99 73.57,35.99 73.3,36.26 73.3,37.3 73.55,37.56 75.74,37.56
+VIN on TOP (solid shape): 162.56,47.14 162.56,46.02 162.33,45.79 160.37,45.79 160.09,46.07 160.09,47.33 160.22,47.45 162.25,47.45
+VIN on TOP (solid shape): 59.06,45.64 59.06,44.24 58.82,44 57.59,44 57.35,44.24 57.35,44.36 57.18,44.53 57.18,45.77 57.27,45.87 58.83,45.87
+VIN on TOP (solid shape): 65.35,52.21 65.35,50.84 65.12,50.61 63.09,50.61 62.81,50.89 62.81,52.28 63.31,52.31 63.8,52.39 65.17,52.39
+VIN on TOP (solid shape): 70.12,56.48 70.12,55.38 69.97,55.23 69.08,55.23 68.7,54.85 67.81,54.85 67.56,55.1 67.56,57.58 67.79,57.81 68.8,57.81
+VIN on BOTTOM (solid shape): 37.55,19.16 37.55,17.74 37.37,17.56 35.6,17.56 35.37,17.79 35.37,19.31 35.55,19.49 37.22,19.49
+VIN on BOTTOM (solid shape): 165.02,22.51 165.02,20.24 164.92,20.13 164,20.13 163.81,20.33 163.81,22.61 163.93,22.73 164.8,22.73
+VIN on BOTTOM (solid shape): 64.04,34.29 64.04,33.22 63.87,33.05 61.92,33.05 61.72,33.26 61.72,34.28 62.62,34.28 62.62,34.43 63.9,34.43
+VIN on BOTTOM (solid shape): 180.59,33.52 180.59,32.5 180.13,32.04 176.54,32.04 176.47,32.12 176.19,32.12 175.64,32.68 175.64,33.67 175.74,33.77 180.33,33.77
+VIN on BOTTOM (solid shape): 83.84,23.57 84.07,23.5 84.29,23.57 84.87,23.57 85.14,23.31 85.14,21.22 85.06,21.15 85.06,20.64 84.97,20.55 84.97,20.04 84.99,20.01 84.99,19.98 85.03,19.98 85.08,19.93 85.52,19.93 85.72,19.73 85.72,19.27 85.47,19.01 83.81,19.01 83.66,19.17 83.66,23.43 83.8,23.57
+VIN on BOTTOM (solid shape): 76.58,21.22 76.58,20.94 76.45,20.82 75.99,20.82 75.86,20.69 75.86,20.61 75.81,20.56 75.81,20.16 76.42,19.55 76.42,19.11 76.78,18.75 76.97,18.75 77.11,18.7 77.26,18.71 77.3,18.73 77.39,18.72 77.44,18.63 77.44,18.55 77.43,18.54 78.07,17.9 78.07,13.63 77.74,13.3 73.96,13.3 73.81,13.45 73.81,18.38 73.63,18.56 73.63,21.05 73.96,21.38 76.42,21.38
+VIN on IN2 (solid shape): outline of 541 points within 159.05,31.66 179.6,47.02
+VIN on SVCC (solid shape): outline of 215 points within 38.35,2.04 181.15,59.97
+VIN on IN3 (solid shape): outline of 185 points within 73.96,18.48 85.08,24.3
+VIN on IN4 (solid shape): outline of 512 points within 35.27,16.72 48.94,21.99
+VIN_PANEL on BOTTOM (solid shape): 32.06,17.15 32.6,16.93 33.14,17.15 36.51,17.15 36.62,17.04 36.62,14.5 36.51,14.39 36.51,13.91 36.22,13.62 31.4,13.62 31.4,14.29 31.2,14.29 31.2,13.62 30.9,13.62 30.9,14.29 30.7,14.29 30.7,13.62 30.4,13.62 30.4,16.9 30.66,17.15
+VIN_VCC_CORE on TOP (solid shape): 187.04,40.1 187.04,36.85 186.84,36.64 186.23,36.64 186.13,36.54 186.13,32.6 185.87,32.35 183.18,32.35 183,32.53 183,34.86 183.18,35.04 183.89,35.04 184.45,35.6 184.45,40.12 184.63,40.3 186.84,40.3
+VIN_VCC_CORE on BOTTOM (solid shape): 184.7,35.07 184.7,32.45 184.4,32.15 181.63,32.15 181.27,32.5 181.27,33.54 181.3,33.54 181.83,34.08 181.83,34.64 181.96,34.76 182.24,34.76 182.77,35.3 184.47,35.3
+VIN_VCC_CORE on IN1 (solid shape): 185.96,34.93 185.96,32.36 185.67,32.07 183.84,32.07 183.5,32.42 183.5,34.8 183.89,35.18 185.71,35.18
+VIN_VCC_CORE on IN2 (solid shape): 185.96,34.93 185.96,32.36 185.67,32.07 183.84,32.07 183.5,32.42 183.5,34.8 183.89,35.18 185.71,35.18
+VIN_VCC_CORE on IN3 (solid shape): 185.96,34.93 185.96,32.36 185.67,32.07 183.84,32.07 183.5,32.42 183.5,34.8 183.89,35.18 185.71,35.18
+VIN_VCC_CORE on IN4 (solid shape): 185.96,34.93 185.96,32.36 185.67,32.07 183.84,32.07 183.58,32.34 183.58,34.88 183.89,35.18 185.71,35.18
+VIN_VCCGT on TOP (solid shape): 172.33,39.66 172.33,35.45 172.71,35.07 172.71,32.81 172.33,32.43 170.63,32.43 169.39,33.67 169.39,34.16 169.44,34.35 169.39,34.54 169.39,38.47 169.72,38.8 170.76,38.8 171.06,39.11 171.06,39.64 171.29,39.87 172.13,39.87
+VIN_VCCGT on BOTTOM (solid shape): 174.31,35.09 174.31,34.33 174.67,33.98 174.67,32.55 174.42,32.3 171.32,32.3 170.99,32.63 170.99,34.86 171.57,35.45 173.96,35.45
+VIN_VCCGT on IN1 (solid shape): 173.98,35.53 173.98,32.52 173.75,32.29 170.16,32.29 169.94,32.52 169.94,35.51 170.17,35.74 173.77,35.74
+VIN_VCCGT on IN4 (solid shape): 173.46,35.49 173.46,32.56 173.19,32.29 170.16,32.29 169.94,32.52 169.94,35.51 170.17,35.74 173.21,35.74
