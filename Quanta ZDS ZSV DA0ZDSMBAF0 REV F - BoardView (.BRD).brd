# Allegro board Quanta ZDS ZSV DA0ZDSMBAF0 REV F - BoardView (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M1_B_A3: length 41.5
  IN2 w0.06: 117.95,30.21 117.95,32.52 118.16,32.73 118.16,35.66 117.92,35.9 v14(117.92,36.33)
  IN2 w0.109: 117.95,30.21 118.1,30.06 118.1,26.74 116.65,25.28 116.65,18.78 116.57,18.7 116.35,18.7 116.28,18.78 116.28,21.06 116.2,21.14 115.96,21.14 115.88,21.06 115.88,19.06 114.97,18.15 114.97,16.6 114.47,16.09 114.47,15.2 112.84,13.57 108.67,13.57 108.35,13.25 104.41,13.25 103.63,14.04 103.63,14.13 103.35,14.4 v13(103.35,14.96)
  BOTTOM w0.102: v13(103.35,14.96) 103.67,15.28 U4A1.N3
M1_B_A4: length 40.3
  IN2 w0.06: v14(117.6,37.04) 117.6,36.34 117.24,35.98 117.24,35.6 117.11,35.47 117.11,31.51 117.11,31.5 117.11,31.35 117.01,31.25
  IN2 w0.109: 117.01,31.25 117.01,30.36 117.11,30.26 117.11,27.18 114.85,24.92 114.85,20.2 114.62,19.97 114.62,17.34 114.54,17.25 114.42,17.25 114.33,17.34 114.33,19.4 114.24,19.49 114.13,19.49 114.04,19.4 114.04,15.18 112.71,13.86 108.55,13.86 108.24,13.55 104.57,13.55 104.36,13.75 104.36,14.61 v13(104,14.96)
  BOTTOM w0.102: U4A1.M3 104.32,15.28 v13(104,14.96)
M1_B_A5: length 36.9
  IN2 w0.06: 115.91,30.29 116.07,30.45 116.07,31.25 116.74,31.91 116.74,35.64 116.84,35.73 116.84,36.1 v14(116.63,36.3)
  IN2 w0.109: v13(108.54,14.96) 108.78,15.2 110.05,15.2 110.23,15.38 110.23,16.17 110.17,16.24 110.17,16.71 110.46,17 112.02,17 112.16,17.14 112.16,17.63 112.03,17.76 109.29,17.76 109.16,17.89 109.16,18.17 109.29,18.3 110.33,18.3 110.48,18.14 112.77,18.14 112.87,18.25 112.87,18.52 112.78,18.62 111.1,18.62 111,18.71 111,18.85 111.1,18.95 112.78,18.95 112.87,19.04 112.87,19.97 113.66,20.76 113.66,25.41 115.91,27.66 115.91,30.29
  BOTTOM w0.102: U4A1.F3 108.22,15.28 v13(108.54,14.96)
M1_B_A6: length 42.6
  IN2 w0.06: v14(118.57,36.8) 118.2,36.43 118.2,36.29 118.04,36.14 118.04,35.96 118.28,35.72 118.28,32.62 118.1,32.44 118.1,30.31
  IN2 w0.109: 118.1,30.31 118.41,30 118.41,26.63 116.94,25.16 116.94,15.96 116.86,15.88 116.63,15.88 116.55,15.96 116.55,18.32 116.48,18.4 116.25,18.4 116.17,18.32 116.17,16.54 116.1,16.47 115.84,16.47 115.77,16.54 115.77,18.07 115.69,18.14 115.44,18.14 115.36,18.07 115.36,16.57 114.76,15.97 114.76,15.8 114.85,15.7 115.46,15.7 115.54,15.63 115.54,15.4 115.46,15.32 114.89,15.32 114.76,15.2 114.76,15.07 113.09,13.4 113.09,13.4 112.96,13.28 109.77,13.28 109.68,13.19 v13(109.28,13.19)
  BOTTOM w0.102: v13(109.28,13.19) 109.17,13.3 109.17,15 U4A1.E3
M1_B_A7: length 41.7
  IN2 w0.06: 118.28,30.39 118.28,32.44 118.41,32.57 118.41,35.89 v14(118.24,36.06)
  IN2 w0.109: 118.28,30.39 118.71,29.95 118.71,26.52 117.23,25.04 117.23,24.75 117.32,24.66 117.51,24.66 117.6,24.57 117.6,24.4 117.51,24.32 117.32,24.32 117.23,24.23 117.23,24.06 117.32,23.97 117.51,23.97 117.6,23.88 117.6,23.72 117.51,23.63 117.32,23.63 117.23,23.54 117.23,15.83 116.95,15.55 116.62,15.55 116.53,15.46 116.53,15.21 116.44,15.12 116.26,15.12 116.17,15.21 116.17,15.83 116.1,15.91 115.91,15.91 115.83,15.83 115.83,14.43 114.33,12.93 114.22,12.93 114.07,13.09 114.07,13.19 115.05,14.18 115.05,14.29 114.89,14.44 114.79,14.44 113.33,12.99 110.03,12.99 109.58,12.54 108.96,12.54 108.87,12.63 v13(108.87,12.75)
  BOTTOM w0.147: v13(108.87,12.75) 108.9,12.72 108.9,12.38 108.82,12.3 108.6,12.3 107.85,13.05 107.85,13.28 107.97,13.39 108.77,13.39 108.87,13.49 108.87,13.63 108.6,13.9 108.6,14.04 108.87,14.31 U4A1.E2
M1_B_A8: length 37.2
  IN2 w0.06: 115.46,30.82 115.46,31 116.5,32.03 116.5,35.62 116.43,35.69 116.43,36.52 v14(116.96,37.04)
  IN2 w0.109: 115.46,30.82 115.46,30.12 115.62,29.96 115.62,27.78 113.37,25.53 113.37,20.94 112.52,20.09 112.52,19.34 112.41,19.24 110.97,19.24 110.32,18.59 108.15,18.59 108.08,18.66 106.51,18.66 106.42,18.58 106.42,18.46 106.51,18.37 107.8,18.37 107.89,18.28 107.89,18.16 107.8,18.07 105.9,18.07 105.81,17.98 105.81,17.85 105.9,17.76 108.81,17.76 108.99,17.58 108.99,16.57 v13(109.86,15.7)
  BOTTOM w0.102: U4A1.D2 109.86,14.83 v13(109.86,15.7)
M1_B_A9: length 41.7
  IN2 w0.06: v14(118.57,36.3) 118.57,36.1 118.54,36.08 118.54,32.42 118.46,32.34
  IN2 w0.109: 118.46,32.34 118.46,30.46 119.04,29.88 119.04,26.44 118.6,25.99 118.6,24.21 118.52,24.14 118.33,24.14 118.26,24.21 118.26,25.28 118.18,25.36 117.99,25.36 117.91,25.28 117.91,23.37 117.82,23.28 117.63,23.28 117.54,23.2 117.54,23.03 117.63,22.94 117.82,22.94 117.91,22.85 117.91,22.69 117.82,22.6 117.63,22.6 117.54,22.51 117.54,22.34 117.63,22.26 117.82,22.26 117.91,22.17 117.91,22 117.82,21.91 117.63,21.91 117.54,21.82 117.54,21.66 117.63,21.57 117.82,21.57 117.91,21.48 117.91,21.32 117.82,21.23 117.63,21.23 117.54,21.14 117.54,20.97 117.63,20.88 117.82,20.88 117.91,20.79 117.91,20.63 117.82,20.54 117.63,20.54 117.54,20.45 117.54,20.29 117.63,20.2 117.82,20.2 117.91,20.11 117.91,19.94 117.82,19.86 117.63,19.86 117.54,19.77 117.54,19.6 117.63,19.51 117.82,19.51 117.91,19.42 117.91,19.26 117.82,19.17 117.63,19.17 117.54,19.08 117.54,18.92 117.63,18.83 117.81,18.83 117.9,18.74 117.9,18.59 117.81,18.5 117.62,18.5 117.55,18.42 117.55,18.27 117.62,18.19 117.7,18.19 117.77,18.12 117.77,18 117.52,17.75 117.52,15.71 114.4,12.59 v13(110.19,12.59)
  BOTTOM w0.147: v13(110.19,12.59) 109.75,12.59 109.62,12.72 109.62,12.96 109.75,13.09 110.48,13.09 110.61,13.22 110.61,13.44 110.48,13.57 109.57,13.57 109.44,13.7 109.44,13.9 109.57,14.03 110.05,14.03 110.17,14.15 U4A1.C2
M1_B_ZQ0: length 5.6
  BOTTOM w0.102: U4A1.B3 110.92,15.2 110.92,15.03 111.1,14.84 111.1,13.15
  BOTTOM w0.117: 111.1,13.15 111.1,11.62 110.79,11.31 v4(110.79,10.75) R4L1.2
M1_B_ZQ1: length 6.9
  BOTTOM w0.102: U4A1.B4 110.82,16.08 111.2,15.71 111.2,15.41 111.19,15.41 111.19,15.11 111.45,14.85 111.58,14.85 111.75,14.67 111.75,13.15
  BOTTOM w0.117: 111.75,13.15 111.75,12.78 111.86,12.68 111.86,11.44 112.11,11.18 v4(112.11,10.73) 112.11,10.5 111.86,10.24 R4L2.2
M1_CKE0: length 42.7
  IN1 w0.06: v11(117.6,34.58) 117.6,34.34 117.37,34.11 117.37,31.69 116.86,31.17 116.86,30.64 116.41,30.19 116.41,29.89
  IN1 w0.089: 116.41,29.89 116.41,27.46 114.65,25.7 114.65,17.35 115.06,16.95 115.06,15.09 115.13,15.02 v4(115.13,14.84)
  IN3 w0.109: v13(105.25,14.89) 105.68,14.46 113.13,14.46 113.51,14.84 v4(115.13,14.84) 115.89,14.84 116.1,14.64 116.1,14.38 116.22,14.26 116.45,14.26 116.57,14.38 116.57,14.74 116.7,14.87 116.89,14.87 117.02,14.74 117.02,14.36 117.14,14.23 117.33,14.23 117.46,14.36 117.46,14.82 117.61,14.98 117.77,14.98 117.9,14.85 117.9,14.71 118.1,14.52 122.65,14.52 123.02,14.89 v13(123.02,14.92)
  BOTTOM w0.102: U5A1.K3 123.02,14.92 v13(123.02,14.92) ; U4A1.K3 105.25,14.92 v13(105.25,14.89)
M1_CKE1: length 39.9
  IN1 w0.06: v11(117.28,35.32) 117.28,35.11 117.48,34.91 117.48,34.74 117.4,34.66 117.4,34.35 117.25,34.2 117.25,31.74 116.71,31.2 116.71,30.68 116.18,30.15 116.18,29.89
  IN1 w0.089: v4(114.6,16.87) 114.34,17.13 114.34,25.83 116.18,27.67 116.18,29.89
  IN3 w0.109: v13(123.07,15.73) 123.07,16.63 122.83,16.87 v4(114.6,16.87) 112.02,16.87 111.94,16.95 105.78,16.95 v13(105.3,16.47)
  BOTTOM w0.102: U5A1.K4 123.07,15.77 v13(123.07,15.73) ; U4A1.K4 105.3,16.41 v13(105.3,16.47)
M1_CS0_N: length 44.3
  IN1 w0.06: 115.01,29.89 115.01,30.36 116.65,32.01 116.65,34.43 116.64,34.45 116.64,34.65 116.63,34.65 v11(116.63,34.83)
  IN1 w0.089: 115.01,29.89 115.01,28.56 112.36,25.92 112.36,18.64 112.27,18.54 111.45,18.54 111.34,18.44 111.34,18.21 111.45,18.1 112.23,18.1 112.36,17.97 112.36,15.38 v4(112.41,15.33)
  IN3 w0.109: v13(104.62,14.94) 105,15.33 108.7,15.33 108.7,15.33 109.24,15.33 109.36,15.21 109.36,14.99 109.48,14.86 109.67,14.86 109.8,14.99 109.8,15.2 109.93,15.33 110.61,15.33 110.68,15.39 110.68,15.64 110.82,15.79 110.97,15.79 111.12,15.64 111.12,14.96 111.27,14.81 111.41,14.81 111.56,14.96 111.56,15.18 111.7,15.33 v4(112.41,15.33) 120.69,15.33 121.08,14.94 v13(122.39,14.94)
  BOTTOM w0.102: U5A1.L3 122.39,14.94 v13(122.39,14.94) ; v13(104.62,14.94) 104.62,14.94 U4A1.L3
M1_CS1_N: length 46.6
  IN1 w0.06: 116.64,29.99 116.64,30.19 116.99,30.54 116.99,31.12 117.81,31.95 117.81,32.82 117.73,32.9 117.58,32.9 117.52,32.96 117.52,33.07 117.58,33.13 117.74,33.13 117.8,33.19 117.8,33.27 117.74,33.33 117.55,33.33 117.49,33.39 117.49,33.48 117.55,33.54 117.75,33.54 117.81,33.6 117.81,34.34 117.8,34.35 117.8,34.66 117.72,34.74 117.72,34.91 117.8,34.99 117.8,35.16 117.69,35.27 117.69,35.48 v11(117.6,35.57)
  IN1 w0.089: v4(115.54,16.14) 115.54,17.33 115.44,17.43 115.11,17.43 115.01,17.54 115.01,17.65 115.11,17.76 115.44,17.76 115.54,17.86 115.54,18 115.44,18.09 115.07,18.09 114.96,18.2 114.96,18.34 115.07,18.45 115.41,18.45 115.54,18.57 115.54,19.13 115.13,19.54 115.13,25.71 116.64,27.22 116.64,29.99
  IN3 w0.109: v13(104.64,15.7) 104.97,16.03 105.68,16.03 105.78,16.14 v4(115.54,16.14) 115.89,16.49 116.52,16.49 116.68,16.34 116.68,15.98 116.78,15.88 117.02,15.88 117.12,15.98 117.12,16.31 117.25,16.44 117.43,16.44 117.56,16.31 117.56,15.93 117.66,15.83 117.9,15.83 118,15.93 118,16.31 118.18,16.49 120.72,16.49 120.9,16.31 120.9,15.76 121.02,15.63 121.21,15.63 121.34,15.76 121.34,16.38 121.46,16.49 122.35,16.49 122.49,16.35 v13(122.49,15.7)
  BOTTOM w0.102: v13(104.64,15.7) 104.64,15.76 U4A1.L4 ; U5A1.L4 122.74,16.02 122.49,15.76 v13(122.49,15.7)
MASTER_SCL: length 6.9
  BOTTOM w0.117: U40.29 224.12,24.47 224.91,25.25 R10980.2 225.55,26.26 v4(225.55,27.16) 225.55,28.05 R260.2 226.13,28.1 226.22,28.19 Q18.6
MASTER_SDA: length 9.4
  IN4 w0.071: v8(225.04,27.03) v8(228.21,27.03)
  BOTTOM w0.117: Q18.3 228.35,26.89 v8(228.21,27.03) ; U40.28 v4(223.62,24.62) 223.62,24.98 223.89,25.25 R10981.2 224.27,25.63 224.4,25.76 224.4,27.24 224.48,27.32 R259.2 224.75,27.32 v8(225.04,27.03)
MBCLK: length 45.8
  IN4 w0.071: v8(60.93,22.13) 62,22.13 62.2,21.93 v8(62.2,21.78) 62.22,21.76 62.36,21.76 62.6,21.52 62.6,21.51 62.61,21.5 62.61,21.15 62.21,20.76 62.1,20.76 61.9,20.95 61.78,20.95 61.7,20.87 61.7,20.75 61.89,20.55 61.89,20.44 61.81,20.35 61.69,20.35 61.5,20.55 61.38,20.55 61.3,20.47 61.3,20.35 61.49,20.15 61.49,20.03 61.41,19.95 61.29,19.95 61.09,20.15 60.98,20.15 60.89,20.06 60.89,19.95 61.09,19.75 61.09,19.63 61.01,19.55 60.89,19.55 60.69,19.74 60.57,19.74 60.49,19.66 60.49,19.54 60.69,19.35 60.69,19.23 60.6,19.15 60.49,19.15 60.29,19.34 60.17,19.34 60.09,19.26 60.09,19.14 60.29,18.95 60.29,18.83 60.2,18.74 60.08,18.74 59.89,18.94 59.77,18.94 59.69,18.86 59.69,18.74 59.88,18.54 59.88,17.6 59.44,17.15 59.44,17.03 59.52,16.95 59.64,16.95 60.08,17.4 60.2,17.4 60.29,17.31 60.29,17.2 59.84,16.75 59.84,16.63 59.92,16.55 60.04,16.55 60.49,16.99 60.6,16.99 60.69,16.91 60.69,16.79 60.24,16.35 60.24,16.23 60.33,16.15 60.44,16.15 60.89,16.59 61.01,16.59 61.74,15.86 62.63,15.86 62.85,15.64 63.86,15.64 64.26,15.25 64.53,15.25 64.61,15.16 64.61,14.9 64.7,14.82 64.81,14.82 64.9,14.9 64.9,15.16 64.98,15.25 65.1,15.25 65.18,15.16 65.18,14.9 65.27,14.82 65.38,14.82 65.47,14.9 65.47,15.16 65.55,15.25 65.67,15.25 65.75,15.16 65.75,14.9 65.83,14.82 65.95,14.82 66.04,14.9 66.04,15.16 66.12,15.25 66.75,15.25 66.97,15.02 v8(66.97,14.59)
  BOTTOM w0.076: U17.B4 53.39,13.51 53.63,13.76 53.63,14 53.69,14.05 53.69,14.8 53.82,14.93
  BOTTOM w0.117: 53.82,14.93 53.98,15.09 53.98,16.46 54.15,16.63 54.15,17.01 54.42,17.28 R360.2 54.55,17.74 54.4,17.89 R341.1 54.57,18.24 54.81,18.47 54.81,19.29 v4(55.29,19.77) 55.29,20.02 56.59,21.32 56.97,21.32 57.37,21.72 Q6072.6 59.38,21.72 59.79,22.13 v8(60.93,22.13) ; v8(66.97,14.59) 67.46,14.11 PD3.1 69.74,14.11 PC220.2 70.28,13.58 PR309.2 ; PR239.1 62.55,23.07 62.2,22.72 v8(62.2,21.78)
MBDATA: length 45.4
  IN3 w0.094: v7(54.58,22.44) 54.58,20.84 55.82,19.59 55.82,18.57 56.13,18.27 58.77,18.27 v7(58.95,18.45)
  IN4 w0.071: v7(54.58,22.44) 54.58,22.54 v8(54.93,22.89) ; v8(62.33,21.4) 61.57,21.4 v8(59.18,19.01) 58.95,18.78 v7(58.95,18.45) 58.95,17.14 60.5,15.58 62.52,15.58 62.73,15.37 63.53,15.37 64.35,14.54 v8(66.59,14.54)
  BOTTOM w0.076: 55.01,14.93 54.39,14.3 U17.A2
  BOTTOM w0.117: v8(62.33,21.4) 62.52,21.6 PR244.1 ; PR314.2 69.85,12.64 PC229.2 69.09,12.51 68.78,12.21 PD6.1 67.82,10.4 67.66,10.24 66.8,10.24 66.62,10.42 66.62,14.52 v8(66.59,14.54) ; v8(54.93,22.89) 55.06,23.02 Q6072.3 ; R331.2 59.18,19.52 v8(59.18,19.01) 58.39,18.22 v4(57.27,18.22) 57.27,18.22 R323.1 56.2,17.71 56.48,17.44 56.48,16.39 55.01,14.93
ME_WR#: length 58.2
  IN2 w0.094: v4(54.4,16.32) 55.87,17.79 55.87,22.71 61.48,28.32 66.16,28.32 66.33,28.15 75.95,28.15 77.35,26.75 85.51,26.75 v4(88.28,29.52)
  BOTTOM w0.076: 54.23,14.93 53.89,14.59 U17.A3
  BOTTOM w0.117: v4(54.4,16.32) v4(54.4,15.6) 54.4,15.1 54.23,14.93 ; v4(88.28,29.52) 89.53,30.77 95.02,30.77 95.83,29.95 95.83,28.63 96.31,28.15 v4(96.31,27.47) R244.1
MIC2-VREFO: length 13.4
  IN3 w0.254: v4(248.97,4.08) 250.42,5.53 252.91,5.53 253.77,6.39 255.65,6.39 v4(255.95,6.7)
  BOTTOM w0.203: U19.29 248.55,4.67
  BOTTOM w0.254: R422.1 256.11,10.05 256.1,10.05 256.1,9.38 256.11,9.38 v4(256.11,9.24) R447.1 256.11,6.85 v4(255.95,6.7) ; v4(248.97,4.08) 248.97,4.26 248.55,4.67
ML0N: length 6.3
  BOTTOM w0.117: U13.10 248.91,21.1 248.86,21.05 248.6,21.05 248.11,20.56 248.11,20.3 246.99,19.18 246.61,19.18 v4(246.12,19.67) 245.67,19.22 244.92,19.22 C337.2
ML0P: length 6.3
  BOTTOM w0.117: C351.2 244.87,18.92 245.6,18.92 v4(246.12,18.4) 246.61,18.88 247.11,18.88 248.41,20.17 248.41,20.44 248.72,20.75 248.91,20.75 248.96,20.7 U13.9
ML1N: length 5.5
  BOTTOM w0.117: C322.2 244.91,21.01 245.13,21.01 245.83,21.7 247.65,21.7 248.2,22.25 248.71,22.25 248.76,22.3 U13.13
ML1P: length 5.4
  BOTTOM w0.117: U13.12 248.76,21.9 248.71,21.95 248.32,21.95 247.77,21.4 245.95,21.4 245.26,20.71 244.88,20.71 C328.2
ML2N: length 3.2
  BOTTOM w0.117: C305.2 246.94,24.06 247.1,24.06 247.71,23.45 248.71,23.45 248.76,23.5 U13.16
ML2P: length 3.2
  BOTTOM w0.117: U13.15 248.76,23.1 248.71,23.15 247.59,23.15 246.98,23.76 246.92,23.76 C309.2
ML3N: length 3.4
  BOTTOM w0.117: C297.2 246.95,25.83 247.41,25.83 248.59,24.65 248.86,24.65 248.91,24.7 U13.19
ML3P: length 3.4
  BOTTOM w0.117: U13.18 248.91,24.3 248.86,24.35 248.47,24.35 247.29,25.53 246.92,25.53 C301.2
MOD_ID1: length 5.4
  BOTTOM w0.117: U40.27 223.12,25.13 222.88,25.37 R10997.2 223.26,26.01 R10996.1 222.67,27.53 v4(222.37,27.24)
MOD_ID2: length 5.5
  BOTTOM w0.117: v4(230.42,20.3) 230.16,20.04 R10994.2 228.48,20.04 R10995.2 227.97,20.56 226.69,20.56 226.19,21.05 U40.34
MPHY_EXT_PWR: length 1.2
  IN2 w0.064: v3(109.71,36.98) v9(109.02,36.98)
  GND2 w0.127: v8(109.14,36.51) 109.14,36.86 v9(109.02,36.98)
MUTE_LED_EC: length 214.9
  IN3 w0.094: v8(53.44,14.46) 53.44,14.28 54.64,13.08 54.64,9.96 53.45,8.77 53.4,8.77 53.16,8.53 50.87,8.53 50.03,7.69 50.03,5.87 51.5,4.4 53.92,4.4 54.25,4.07 56.92,4.07 58.16,5.32 58.9,5.32 59.58,5.99 63.15,5.99 68.66,11.5 72.96,11.5 73.58,12.13 75.12,12.13 75.7,11.55 77.71,11.55 78.4,12.25 78.8,12.25 79.5,11.55 89.24,11.55 96.33,4.46 130.93,4.46 132.29,3.1 137.09,3.1 137.79,2.4 184.63,2.4 191.03,8.8 199.6,8.8 200.81,10.01 205.09,10.01 208.39,13.31 216.65,13.31 216.91,13.57 217.93,13.57 218.51,14.16 219.95,14.16 223.64,17.85 226.99,17.85 229.99,14.84 v8(230.5,14.84)
  BOTTOM w0.076: U17.A4 53.39,14.41 v8(53.44,14.46) 53.44,14.93
  BOTTOM w0.117: D36.1 232.12,13.82 v4(231.11,14.84) v8(230.5,14.84) ; 53.44,14.93 53.71,15.2 53.71,16.57 53.79,16.65 R359.1
MX0: length 12.1
  IN4 w0.071: v8(43.25,11.49) 43.61,11.85 45.47,11.85 46.72,10.59 48.54,10.59 49.22,9.91 v8(49.39,9.91)
  BOTTOM w0.117: v8(43.25,11.49) 43.25,11.36 v4(42.79,10.9) 41.7,9.81 39.82,9.81 39.65,9.64 CN11.3
MX1: length 12.1
  IN4 w0.071: v8(48.89,9.91) 48.15,9.91 47.77,10.29 46.63,10.29 45.95,10.98 42.52,10.98 v8(42.36,11.13)
  BOTTOM w0.117: CN11.4 38.85,9.55 39.49,10.19 41.47,10.19 v4(41.6,10.32) 42.36,11.08 42.36,11.21 ; v8(42.36,11.13) 42.36,11.21 ; 42.36,11.21 42.36,11.21 C410.1
MX2: length 16.3
  IN4 w0.071: v8(41.93,12.48) 42.14,12.27 45.63,12.27 46.89,11.01 48.72,11.01 48.95,10.78 49.65,10.78 49.9,10.52 49.9,10.24 50.24,9.91 v8(50.89,9.91)
  BOTTOM w0.117: v8(41.93,12.48) 41.93,11.76 41.7,11.53 C409.1 41.47,11.36 40.66,10.55 v4(39.11,10.55) 38.92,10.55 38.05,9.68 CN11.5
MX3: length 17.1
  IN4 w0.071: v8(49.39,10.41) 48.92,10.41 48.6,10.73 46.77,10.73 45.51,11.99 43.25,11.99 42.79,11.54 38.46,11.54 v8(38.25,11.75)
  BOTTOM w0.117: v8(38.25,11.75) 38.02,11.53 C405.1 37.69,11.42 v4(37.69,10.93) 37.36,10.6 36.65,10.6 36.16,10.12 35.4,10.12 34.85,9.56 CN11.9
MX4: length 25.1
  IN4 w0.071: v8(32,11.88) 33.68,11.88 35.32,13.52 43.35,13.52 44.16,12.71 46.77,12.71 48.07,11.42 48.9,11.42 49.13,11.19 49.98,11.19 50.76,10.41 v8(50.89,10.41)
  BOTTOM w0.117: v8(32,11.88) 32,11.79 31.73,11.53 C398.1 31.05,11.01 30.58,11.01 29.25,9.68 CN11.16
MX5: length 26.7
  IN4 w0.071: v8(29.79,11.49) 30.44,12.14 31.31,12.14 31.8,11.65 33.64,11.65 34.57,12.58 35.43,12.58 36.14,13.29 43.28,13.29 43.99,12.58 45.7,12.58 47,11.28 48.85,11.28 49.07,11.05 49.87,11.05 50.39,10.54 v8(50.39,10.41)
  BOTTOM w0.117: C396.1 29.32,11.06 28.72,11.06 v4(28.11,10.45) 27.65,9.98 CN11.18
MX6: length 25.1
  IN4 w0.071: v8(48.53,10.28) 48.35,10.46 46.66,10.46 46,11.12 43.15,11.12 42.86,11.4 38.02,11.4 37.8,11.62 35.49,11.62 35.42,11.69 33.88,11.69 33.7,11.51 31.74,11.51 31.25,12 30.7,12 29.96,11.26 29.13,11.26 v8(28.9,11.49)
  BOTTOM w0.117: U17.H13 48.67,10.41 v8(48.53,10.28) ; CN11.19 26.85,10.31 v4(26.84,10.4) 27.43,10.98 28.39,10.98 28.65,11.24 28.65,11.24 v8(28.9,11.49)
MX7: length 29.4
  IN4 w0.071: v8(50.89,10.91) 50.46,10.91 50.05,11.33 49.2,11.33 48.98,11.55 48.14,11.55 46.84,12.85 44.22,12.85 43.33,13.75 35.1,13.75 33.73,12.38 28.08,12.38 v8(27.55,11.85)
  BOTTOM w0.117: v8(27.55,11.85) 27.23,11.53 C393.1 26.78,11.53 26.26,11.01 26,11.01 v4(25.44,10.45) 25.25,10.25 CN11.21
MY0: length 18.9
  IN4 w0.071: v8(38.48,10.45) 40.6,10.45 40.91,10.15 45.58,10.15 46.34,9.39 46.96,9.39 47.8,8.55 48.7,8.55 48.9,8.74 51.06,8.74 51.39,8.41 v8(51.39,8.41)
  BOTTOM w0.117: CN11.6 37.25,9.76 37.43,9.94 37.96,9.94 v8(38.48,10.45) 38.95,10.93 v4(40.43,10.93) 40.58,11.08 C408.1
MY1: length 18.9
  IN4 w0.071: v8(40.1,11.9) 41.24,13.04 43.02,13.04 43.64,12.42 45.67,12.42 46.95,11.14 48.79,11.14 49.02,10.92 49.8,10.92 50.08,10.63 50.08,10.35 50.26,10.17 51.63,10.17 v8(51.89,9.91)
  BOTTOM w0.117: CN11.7 36.45,9.79 36.85,10.19 37.84,10.19 38.8,11.15 39.19,11.15 C407.1 39.73,11.53 v8(40.1,11.9)
MY2: length 21
  IN4 w0.071: v8(50.89,7.91) 50.75,7.91 49.85,7.02 48.79,7.02 48.58,6.81 47,6.81 45.83,7.98 45.19,7.98 44.13,9.03 37.43,9.03 37.43,9.05 36.7,9.79 36.19,9.79 v8(36.09,9.74)
  BOTTOM w0.117: CN11.8 35.65,9.68 35.71,9.74 v8(36.09,9.74) 36.72,10.37 37.69,10.37 38.68,11.36 C406.1
MY3: length 21.1
  IN4 w0.071: v8(35.5,10.42) 35.61,10.53 36.95,10.53 37.76,9.72 44.42,9.72 45.43,9.72 46.22,8.93 46.22,8.62 46.73,8.11 48.68,8.11 48.84,7.95 49.65,7.95 49.87,8.17 50.64,8.17 50.89,8.41 v8(50.89,8.41)
  BOTTOM w0.117: CN11.10 34.05,9.5 34.44,9.89 34.74,9.89 35.27,10.42 v8(35.5,10.42) 35.93,10.42 v4(36.29,10.78) 36.93,11.41 C404.1
MY4: length 22
  IN4 w0.071: v8(51.39,9.41) 50.98,9.01 48.87,9.01 48.55,8.69 47.86,8.69 47.02,9.53 46.4,9.53 45.64,10.29 44.44,10.29 44.43,10.29 40.96,10.29 40.55,10.7 37.68,10.7 37.44,10.94 35.03,10.94 v8(35,10.9)
  BOTTOM w0.117: C403.1 36.01,11.23 35.68,10.9 v8(35,10.9) 35,10.7 v4(34.74,10.45) 34.16,10.45 33.25,9.54 CN11.11
MY5: length 22.4
  IN4 w0.071: v8(35.58,11.85) 36.21,12.48 38.78,12.48 39.58,11.67 42.74,11.67 43.19,12.13 45.57,12.13 46.57,11.13 46.83,10.87 48.66,10.87 48.89,10.64 49.56,10.64 49.7,10.5 49.7,10.23 50.24,9.68 51.16,9.68 v8(51.39,9.91)
  BOTTOM w0.117: CN11.12 32.45,9.63 33.27,10.45 v4(33.47,10.45) 33.76,10.45 34.16,10.85 34.44,10.85 C402.1 35.26,11.53 v8(35.58,11.85)
MY6: length 24.3
  IN4 w0.071: v8(50.39,7.91) 49.63,7.15 48.6,7.15 48.46,7.02 46.99,7.02 45.89,8.11 45.24,8.11 44.19,9.17 37.53,9.17 36.72,9.98 36,9.98 35.75,9.73 31.99,9.73 v8(32.02,9.74)
  BOTTOM w0.117: CN11.13 31.65,9.57 31.82,9.74 v8(32.02,9.74) 32.02,10.09 v4(32.2,10.27) 32.25,10.32 32.66,10.32 33.32,10.98 33.85,10.98 34.23,11.36 C401.1
MY7: length 24.3
  IN4 w0.071: v8(50.39,8.41) 49.75,8.41 49.42,8.08 48.89,8.08 48.73,8.24 47.72,8.24 46.85,9.12 46.23,9.12 45.49,9.86 44.36,9.86 44.36,9.86 37.92,9.86 37.11,10.66 35.33,10.66 35.11,10.44 34.51,10.44 34.38,10.58 v8(31.74,10.58)
  BOTTOM w0.117: C400.1 33.34,11.36 32.73,10.75 32.1,10.75 31.93,10.58 v8(31.74,10.58) 31.17,10.58 v4(30.93,10.35) 30.85,10.26 CN11.14
MY8: length 25.6
  IN4 w0.071: v8(30.04,9.79) 30.22,9.96 34.97,9.96 35.05,9.89 35.7,9.89 35.92,10.11 36.78,10.11 37.59,9.31 44.25,9.31 45.3,8.25 45.95,8.25 47,7.2 48.22,7.2 48.36,7.33 49.3,7.33 v8(49.55,7.58)
  BOTTOM w0.117: v8(49.55,7.58) 49.58,7.61 49.58,7.61 U17.N11 ; C399.1 32.46,11.36 31.92,10.83 30.86,10.83 30.04,10.01 v8(30.04,9.79) 30.05,9.57 CN11.15
MY9: length 25
  IN4 w0.071: v8(50.89,9.41) 50.66,9.18 48.7,9.18 48.51,9.38 48.2,9.38 48.17,9.35 47.77,9.35 47.19,9.94 46.57,9.94 45.8,10.7 41.13,10.7 40.72,11.11 37.87,11.11 37.64,11.35 35.37,11.35 35.3,11.42 33.99,11.42 33.81,11.24 30.98,11.24 v8(30.73,11.49)
  BOTTOM w0.117: CN11.17 28.45,9.67 v4(29.48,10.7) 29.94,10.7 v8(30.73,11.49)
MY10: length 30
  IN4 w0.071: v8(26.05,9.82) 26.37,10.14 34.99,10.14 35.1,10.03 35.64,10.03 35.87,10.25 36.83,10.25 37.64,9.44 44.3,9.44 45.36,8.39 46,8.39 47.06,7.34 48,7.34 48.27,7.61 v8(49.07,7.61)
  BOTTOM w0.117: C394.1 27.64,11.16 27,11.16 26.05,10.21 v8(26.05,9.82) CN11.20 ; U17.N12 49.37,7.91 v8(49.07,7.61) 48.31,7.61 v4(47.92,7.22)
MY11: length 35.1
  IN4 w0.071: v8(48.48,7.86) 46.72,7.86 46.08,8.5 46.08,8.87 45.37,9.58 44.47,9.58 44.47,9.58 37.7,9.58 36.89,10.39 35.79,10.39 35.57,10.16 35.22,10.16 35.08,10.31 24.52,10.31 23.97,10.85 23.97,11.49 24.36,11.88 25.84,11.88 v8(26.23,11.49)
  BOTTOM w0.117: v4(46.68,7.47) 47.49,7.47 47.88,7.86 v8(48.48,7.86) 48.53,7.91 U17.N13 ; CN11.22 24.45,10.14 25.8,11.49 v8(26.23,11.49)
MY12: length 28.6
  IN4 w0.071: v8(25.34,11.49) 26.12,10.71 30.18,10.71 30.28,10.81 34.34,10.81 34.57,10.58 35.06,10.58 35.27,10.8 37.2,10.8 37.99,10.01 45.53,10.01 46.28,9.25 46.9,9.25 47.74,8.41 v8(48.89,8.41)
  BOTTOM w0.117: v8(25.34,11.49) 25.34,11.34 25.08,11.07 24.41,11.07 v4(24.17,10.83) 23.65,10.3 CN11.23
MY13: length 30
  IN4 w0.071: v8(24.48,11.44) 24.79,11.75 25.57,11.75 26.47,10.85 30.13,10.85 30.23,10.95 33.91,10.95 34.11,11.14 35.19,11.14 35.26,11.07 37.5,11.07 37.74,10.84 40.61,10.84 41.02,10.43 45.69,10.43 46.46,9.66 47.07,9.66 47.91,8.82 48.09,8.82 48.38,9.12 v8(48.38,9.15)
  BOTTOM w0.117: CN11.24 22.85,10.21 v4(22.93,10.29) 24.16,11.53 C390.1 ; v8(48.38,9.15) 48.4,9.16 48.78,9.16 49.14,9.16 U17.L12
MY14: length 31.1
  IN4 w0.071: v8(48.04,9.1) 47.83,9.1 47.13,9.8 46.51,9.8 45.75,10.57 41.07,10.57 40.67,10.98 37.79,10.98 37.56,11.21 35.31,11.21 35.25,11.28 34.05,11.28 33.86,11.08 30.17,11.08 30.07,10.98 27.65,10.98 26.47,12.17 24.17,12.17 v8(23.49,11.49)
  BOTTOM w0.117: CN11.25 22.05,10.05 v8(23.49,11.49) ; U17.L13 48.86,8.89 48.26,8.89 v8(48.04,9.1) 47.49,8.55 v4(47.49,8.47)
MY15: length 32.6
  IN4 w0.071: v8(48.02,9.72) 47.59,10.15 46.58,10.15 45.89,10.84 41.19,10.84 40.78,11.25 37.97,11.25 37.74,11.49 35.43,11.49 35.36,11.55 33.94,11.55 33.76,11.37 31.68,11.37 31.19,11.86 30.75,11.86 30.01,11.12 27.76,11.12 26.57,12.31 23.42,12.31 v8(22.6,11.49)
  BOTTOM w0.117: U17.K12 49.14,9.66 48.07,9.66 v8(48.02,9.72) 47.53,9.72 v4(47.49,9.76) ; CN11.26 21.25,9.6 22.6,10.96 v8(22.6,11.49)
NB681_3V3_PRIM: length 3.4
  BOTTOM w0.203: PU11.10 163.32,26.58 163.5,26.4 164.02,26.4 164.19,26.22 PC148.1 164.51,25.38 PR222.1 v4(165.22,25.34)
NB681_3V3_VCCIO: length 3.6
  TOP w0.203: PU7.10 56.33,41.82 56.48,41.67 PC55.1 PR38.1 v4(59.46,41.67)
NB681_VIN_PRIM:
  vias: v4(161.59,21.93) v4(162.63,23.35)
NB681_VIN_VCCIO:
  vias: v4(55.82,44.3)
NB681BST_PRIM:
  vias: v4(162.66,27.85)
NB681BST_VCCIO:
  vias: v4(55.75,42.02) v5(55.7,41.09)
NB681EN_PRIM: length 10.7
  IN4 w0.254: v4(160.24,20.13) 158.85,21.52 158.85,25.1 159.13,25.38 v4(159.13,25.89)
  BOTTOM w0.117: v4(160.24,19.41) v4(160.24,20.13)
  BOTTOM w0.203: v4(160.24,20.13) 159.75,20.13 159.75,20.13 PR263.2 158.91,20.13 158.91,20.13 PR264.2 ; PC153.1 158.9,25.5 159.13,25.73 v4(159.13,25.89) 159.32,26.08 PU11.5
NB681EN_VCCIO: length 3.2
  TOP w0.203: PC51.1 51.68,43.03 v4(52.22,42.5) 52.32,42.32 PU7.5
  BOTTOM w0.203: PC51.1 PR135.1 51.99,42.27 v4(52.22,42.5)
NB681PG_PRIM: length 2.3
  BOTTOM w0.117: PU11.13 163.01,25.08 163.42,24.67 v4(163.9,24.67)
  BOTTOM w0.203: PR231.1 PU11.13
NB681PG_VCCIO: length 1.9
  TOP w0.203: PR33.1 57.27,43.19 v4(56.99,43.47) 56.94,43.52 56.61,43.52 56.41,43.32 PU7.13
NB681SW_VCCIO:
  vias: v4(54.32,40.44) v4(54.96,40.6)
NB681VOUT_PRIM: length 12.3
  TOP w0.254: PR57.1 163.68,33.84 v4(163.54,33.97)
  IN4 w0.203: v4(163.54,33.97) 164.63,33.97 165.25,33.36 165.25,26.78 v4(163.67,25.21)
  BOTTOM w0.203: PU11.12 163.3,25.58 v4(163.67,25.21)
NB681VOUT_VCCIO: length 79.7
  TOP w0.203: v1(61.16,33.48) 61.16,33.21 61.84,32.52 64.74,32.52 v4(65.02,32.24) 66.62,30.64 72.18,30.64 73.27,29.55 81.44,29.55 82.58,28.4 85.62,28.4 90.18,23.85 93.39,23.85 95,25.46 v4(95.29,25.46) ; PU7.12 55.97,42.81 v4(56.92,42.81)
  IN1 w0.203: v1(61.16,33.48) 61.14,33.47 57.84,33.47 54.68,36.63 v4(54.68,36.97)
  IN2 w0.203: v4(56.92,42.81) 56.46,42.81 56.17,42.52 56.17,40.89 55.62,40.34 55.62,37.45 55.15,36.97 v4(54.68,36.97)
  BOTTOM w0.203: PR169.2 114.79,35.13 114.09,34.42 114.09,34.41 108.78,29.1 106.08,29.1 102.48,25.51 95.34,25.51 v4(95.29,25.46) ; v4(54.68,36.97) PR165.1
NBSWON#: length 104.1
  IN3 w0.094: v8(44.68,8.13) 44.82,8.28 44.82,9.59 43.38,11.03 43.38,15.43 v7(43.38,15.73)
  IN4 w0.071: v8(49.2,6.73) 48.88,6.73 48.7,6.55 46.94,6.55 45.74,7.75 45.06,7.75 v8(44.68,8.13) ; v8(69.34,51.2) 67.93,51.2 66.92,50.18 66.83,50.18 66.5,49.85 66.5,49.85 66.41,49.77 65.9,49.77 64.18,48.05 64.18,43.86 65.4,42.64 65.4,38.3 65.83,37.87 65.83,35.61 66.01,35.43 66.01,34.21 65.41,33.61 65.41,32.96 64.63,32.18 63.5,32.18 63,31.68 61.92,31.68 56.56,26.32 56.36,26.32 56.13,26.32 54.86,25.06 54.86,23.79 52.75,21.67 52.75,20.56 51.71,19.51 51.71,18.93 52.09,18.55 52.09,16.89 51.36,16.16 48.63,16.16 47.92,16.87 45.59,16.87 44.93,16.21 43.86,16.21 v7(43.38,15.73)
  BOTTOM w0.117: CL1_CL2.2 63.59,2.99 62.81,2.99 PR491.1 62.81,2.99 SW3.3 61.51,2.41 61.3,2.2 58.76,2.2 58.56,2.41 SW3.4 57.91,2.99 57.6,2.67 C470.2 R490.1 55.61,2.09 49.14,2.09 48.51,2.73 48.51,5.01 48.13,5.39 v4(47.11,5.39) 45.22,5.39 44.32,6.29 44.32,7.77 v8(44.68,8.13) 44.68,9.37 R429.1 ; PR71.1 71.98,50.94 71.72,51.2 70.61,51.2 70.4,50.98 v4(69.81,50.98) 69.55,50.98 v8(69.34,51.2) ; v8(49.2,6.73) 49.59,7.12 50.14,7.67 50.14,8.16 U17.M11
NBSWON#_14_13: length 3.8
  BOTTOM w0.203: R429.2 43.07,10.14 42.67,9.74 42.67,9.01 42.72,8.96 v4(42.72,8.45)
  vias: v4(6.34,15.43) v4(7.05,15.43) v4(7.79,14.92) v4(41.98,8.47)
Net_4:
  vias: v1(111.16,48.13)
Net_5:
  vias: v1(111.16,48.63)
Net_6:
  vias: v1(111.09,49.13)
NO_REBOOT: length 9.2
  TOP w0.117: R97.2 100.98,38 v1(101.29,37.68)
  IN1 w0.071: v1(101.29,37.68) 102.01,37.68 102.26,37.94 102.68,37.94 102.7,37.96 104.59,37.96 105.09,37.45 107.37,37.45 107.92,36.9 108.55,36.9 108.58,36.93 108.74,36.93 v1(109.05,37.24)
NVDC#: length 1.9
  GND1 w0.102: v9(69.13,43.91) 69.02,44.02 v2(69.02,44.23)
  GND2 w0.127: v9(69.13,43.91) 69.13,44.03 69.51,44.42 v8(69.57,44.42)
  BOTTOM w0.117: PR115.1 69.69,45.2 69.69,44.92 69.57,44.8 v8(69.57,44.42)
PANEL_CHRG_IN: length 221.1
  IN3 w0.094: v7(48,16.06) 48,16.36 46.55,17.81 46.55,18.88 46.9,19.23 46.9,21.53 49.29,23.91 50.52,23.91 50.97,24.37 53.59,24.37 54.08,23.88 58.35,23.88 60.75,21.47 62.33,21.47 64.64,23.78 67.84,23.78 68.88,24.82 71.02,24.82 71.97,25.77 78.14,25.77 79.07,24.84 84.41,24.84 85.02,24.23 86.57,24.23 88.77,22.03 90.32,22.03 92,20.34 92,17.26 100.38,8.88 126.99,8.88 127.1,8.77 132.34,8.77 132.45,8.88 138.82,8.88 139.43,8.27 145.3,8.27 145.45,8.43 146.88,8.43 147.17,8.15 156.57,8.15 157.39,8.96 158.04,8.96 160.73,6.27 171.32,6.27 171.61,5.98 174.59,5.98 175,6.39 175,6.84 178.51,10.35 179.2,10.35 181.67,12.82 184.75,12.82 186.01,14.08 192.04,14.08 198.19,20.23 198.19,21.88 198.4,22.09 198.4,30.97 196.73,32.65 196.73,35.14 197.58,35.99 197.58,38.27 196.2,39.65 196.2,44.43 196.97,45.2 196.97,45.99 v4(196.78,46.18)
  IN4 w0.071: v8(52.29,13.1) 51.75,13.64 49.83,13.64 49.35,14.13 49.35,14.36 48,15.71 v7(48,16.06)
  BOTTOM w0.076: U17.E7 51.89,12.07 52.13,12.31 52.13,12.93 v8(52.29,13.1)
  BOTTOM w0.117: CN6.6 199.9,50.84 199.76,50.71 199.49,50.71 198.93,50.15 197.89,50.15 197.33,49.59 197.33,46.73 v4(196.78,46.18)
PCBEEP: length 4.8
  BOTTOM w0.117: U19.12 250.15,12.27 250.46,12.58 250.46,12.99 250.31,13.14 v4(250.31,13.49) 250.31,13.72 250.52,13.93 250.52,15.05 251.03,15.56 C356.1
PCBEEP_EC: length 205.7
  IN3 w0.094: v8(51.61,7.25) 51.61,7.05 52.94,5.72 54.43,5.72 54.58,5.87 56.09,5.87 56.72,6.51 58.41,6.51 59.08,7.18 62.66,7.18 68.17,12.69 72.28,12.69 73.08,13.49 79.25,13.49 80,12.74 89.9,12.74 95.85,6.79 98.44,6.79 99.09,6.14 101.98,6.14 102.47,5.65 131.42,5.65 132.78,4.29 137.68,4.29 138.38,3.59 176.9,3.59 181.27,7.97 181.86,7.97 183.32,9.43 185.21,9.43 185.55,9.77 193.16,9.77 195.19,11.8 204.61,11.8 210.49,17.69 211.64,17.69 213.08,19.13 226.46,19.13 229.15,16.44 232.23,16.44 v8(232.28,16.49)
  BOTTOM w0.076: U17.K7 51.64,9.16 51.64,7.56
  BOTTOM w0.117: 51.64,7.56 51.64,7.28 v8(51.61,7.25) ; v8(232.28,16.49) v4(236.98,16.49) 237.61,16.49 238.52,15.59 D19.2
PCH_MBCLK0: length 93.4
  TOP w0.117: v1(100.02,45.27) 100.37,44.92 R54.2
  IN1 w0.06: 103.63,46.27 104.94,46.27 105.68,45.52
  IN1 w0.071: v2(130.04,8.62) 130.55,8.62 130.93,8.24 130.93,7.6 130.56,7.23 122.58,7.23 122.34,7.48 106.3,7.48 104.44,9.33 100.67,9.33 99.46,10.55 99.46,10.85 96.56,13.74 96.56,22.45 93.98,25.03 93.98,27.57 94.92,28.51 94.92,30.3 95.79,31.17 95.79,35.19 96.19,35.6 96.19,40.19 96.51,40.5 96.51,41.48 96.97,41.94 96.97,42.89 97.82,43.74 97.82,44.97 98.15,45.31 99.98,45.31 v1(100.02,45.27) 100.06,45.31 100.51,45.31 101.14,45.94 103.03,45.94 103.36,46.27 103.63,46.27 ; 105.68,45.52 106.7,45.52 107.14,45.96 108.47,45.96 108.91,45.53 109.52,45.53 109.77,45.27 110.41,45.27 111.02,44.66 111.02,43.87 111.12,43.77 111.12,43.23 v1(111.02,43.14)
  GND1 w0.117: v9(130.04,8.28) v2(130.04,8.62)
  GND2 w0.117: v9(130.04,8.28) 130.04,8.35 v8(129.66,8.73)
  BOTTOM w0.117: v8(129.66,8.73) 129.66,9.89 129.37,10.18 Q6066.3
PCH_MBCLK0_C: length 17.7
  BOTTOM w0.117: R543.2 127.35,10.11 127.76,10.52 129.53,10.52 129.88,10.18 Q6066.4 131.66,10.18 131.95,9.89 132.53,9.89 133.35,10.7 133.78,10.7 v4(134.36,11.28) 134.94,10.7 136.61,10.7 C428.2 137.14,11.06 D29.1 138.48,10.65 139.67,10.65 140.86,9.46 140.86,8.57 141.1,8.33 CN12.5
PCH_MBDAT0: length 94.1
  TOP w0.117: v1(106.42,45.02) 106.22,45.02 105.9,45.33 R52.2
  IN1 w0.06: 103.63,45.3 103.68,45.35 104.79,45.35 105.12,45.02 v1(106.42,45.02) 107.31,45.02 107.51,45.22 108.58,45.22 108.66,45.14 109.36,45.14 109.67,44.83 109.67,44.58 v1(109.55,44.45)
  IN1 w0.071: v2(130.42,7.96) 130.42,7.7 130.23,7.51 128.37,7.51 128.3,7.58 128.3,8.65 128.23,8.72 128.08,8.72 128.01,8.65 128.01,7.58 127.94,7.51 127.8,7.51 127.73,7.58 127.73,8.65 127.66,8.72 127.52,8.72 127.44,8.65 127.44,7.58 127.37,7.51 127.23,7.51 127.16,7.58 127.16,8.65 127.09,8.72 126.95,8.72 126.88,8.65 126.88,7.58 126.8,7.51 126.66,7.51 126.59,7.58 126.59,8.65 126.52,8.72 126.38,8.72 126.31,8.65 126.31,7.58 126.24,7.51 122.7,7.51 122.45,7.75 106.41,7.75 104.56,9.61 100.88,9.61 99.85,10.64 99.85,10.84 96.84,13.85 96.84,22.56 94.28,25.13 94.28,27.46 95.22,28.4 95.22,30.21 96.08,31.07 96.08,35.01 96.49,35.41 96.49,39.78 96.79,40.09 96.79,41.31 97.24,41.76 97.24,42.77 98.11,43.64 98.11,44.36 98.57,44.81 103.14,44.81 103.63,45.3
  GND1 w0.117: v9(130.76,8.28) 130.76,8.19 130.52,7.96 v2(130.42,7.96)
  GND2 w0.117: v8(130.68,8.87) 130.68,8.36 v9(130.76,8.28)
PCH_MBDAT0_C: length 17.7
  BOTTOM w0.117: R514.2 127.47,8.62 127.91,8.62 128.17,8.88 Q6066.1 129.02,8.88 129.53,8.36 131.26,8.36 131.54,8.64 131.54,9.3 131.92,9.68 132.58,9.68 133.42,10.52 133.85,10.52 v4(134.36,10.01) 134.87,10.52 136.55,10.52 C418.2 137.14,10.11 D27.1 138.11,10.11 138.47,10.47 139.59,10.47 140.66,9.41 140.66,8.47 140.6,8.41 CN12.6
PCH_PCIE_WAKE#: length 148.8
  TOP w0.089: U3.BP9 109.92,34.04 107.91,34.04 107.79,34.16 107.79,34.35 v1(107.82,34.37)
  IN1 w0.071: v1(107.82,34.37) 107.65,34.54 107.02,34.54 106.93,34.45 106.26,34.45 105.9,34.09 105.63,34.09 104.67,33.13 104.67,32.42 104.66,32.41 104.66,32.41 103.83,31.58 v1(103.58,31.58) 103.58,31.32 103,30.75 100.31,30.75 99.78,30.21 99.78,29.32 98.7,28.25 98.7,26.42 100.18,24.94 100.18,15 100.55,14.63 101.1,14.63 102.76,12.98 106.89,12.98 108.2,11.67 140,11.67 141.11,12.78 156.91,12.78 159.29,15.16 163.73,15.16 166.27,12.62 182.88,12.62 183.13,12.36 185.03,12.36 186.12,13.46 186.12,13.78 188.04,15.7 188.04,17.29 187.84,17.49 187.84,22.14 186.79,23.2 186.79,27.52 187.9,28.64 187.9,33.3 190.49,35.89 v4(190.49,36.66)
  BOTTOM w0.117: R201.2 191.16,38.5 190.49,37.83 v4(190.49,37.7) v4(190.49,36.66)
PCH_PWRBTN#: length 82.9
  TOP w0.102: PU5.K2 68.28,47.99 68.28,48.33 68.3,48.35 68.3,48.71 v2(68.02,48.99)
  GND1 w0.102: v9(68.02,49.32) v2(68.02,48.99)
  IN3 w0.094: v8(105,32.68) 105,32.2 104.78,31.98 104.78,30.68 102.66,28.56 100.32,28.56 99.42,29.46 94.28,29.46 94.28,29.45 93.76,29.45 93.57,29.26 90.27,29.26 88.51,27.49 80.17,27.49 80,27.66 79.99,27.66 79.3,28.35 72.22,28.35 71.66,27.78 68.05,27.78 67.68,27.42 65.37,27.42 65.15,27.64 64.35,27.64 63.85,27.13 63.21,27.13 62.92,27.43 62.92,28.06 62.34,28.63 60.17,28.63 v7(59.86,28.33)
  GND2 w0.117: v9(68.02,49.32) 68.02,49.15 68.39,48.78 v8(68.83,48.78)
  IN4 w0.071: v8(68.83,48.78) 67.96,47.91 67.39,47.91 66.85,47.37 66.85,46.42 66.26,45.83 66.26,45.15 66.65,44.76 66.65,44.47 66.54,44.36 66.54,43.31 66.87,42.98 66.87,42.96 66.92,42.91 66.92,41.99 66.67,41.74 66.67,41.04 66.77,40.95 66.77,40.23 67.14,39.85 67.14,34.17 66.23,33.27 66.23,32.62 64.97,31.36 63.85,31.36 63.34,30.84 62.33,30.84 59.86,28.38 v7(59.86,28.33)
  BOTTOM w0.117: R216.1 105.32,34.26 104.95,33.89 v4(104.95,33.33) 104.95,32.98 105,32.93 v8(105,32.68)
PCH_PWROK: length 102.8
  IN1 w0.071: v2(73.15,42.41) 72.84,42.71 72.2,42.71 71.93,42.98 70.76,42.98 v1(70.52,43.23)
  GND1 w0.06: v2(73.15,42.41) 73.48,42.08 v9(73.48,41.44)
  IN3 w0.094: v7(63.72,27.47) 64.33,28.08 71.54,28.08 72.11,28.65 79.43,28.65 80.27,27.81 88.4,27.81 90.15,29.56 93.44,29.56 93.71,29.83 99.51,29.83 100.47,28.87 102.37,28.87 104.36,30.87 104.36,31.96 104.76,32.35 104.76,32.78 104.92,32.94 104.92,33.56 105.36,34 105.86,34 106.19,34.33 107.59,34.33 108.11,34.85 v8(108.25,34.85)
  GND2 w0.127: v8(73.38,41.01) 73.48,41.11 v9(73.48,41.44)
  IN4 w0.071: v8(73.38,41.01) 73.05,40.68 72.77,40.68 71.9,39.82 71.48,39.82 69.54,37.88 69.54,33.11 68.85,32.42 68.85,31.85 64.48,27.47 v7(63.72,27.47) 63.47,27.47 58.99,22.99 58.99,22.6 57.76,21.37 57.76,20.27 57.14,19.65 57.14,14.61 56.79,14.26 56.79,12.02 55.45,10.68 52.47,10.68 51,12.16 50.03,12.16 v8(49.93,12.25)
  BOTTOM w0.117: v8(108.25,34.85) R218.2 ; U17.D12 49.77,12.41 v8(49.93,12.25) ; v8(73.38,41.01) 73.47,41.1 v4(74.06,41.1) 74.06,40.85 73.96,40.75 PR150.1
PCH_PWROK_R: length 8.9
  TOP w0.06: 110.36,33.46 110.46,33.46 111.31,34.31 U3.BP14
  TOP w0.117: v2(107.84,33.38) 107.92,33.46 110.36,33.46
  GND1 w0.117: v2(107.84,33.38) 107.56,33.66 v9(107.56,33.81)
  GND2 w0.117: v8(107.44,33.34) 107.44,33.69 v9(107.56,33.81)
  BOTTOM w0.117: v8(107.44,33.34) 107.44,33.34 107.44,33.62 107.65,33.83 R218.1 107.8,33.03 C269.1 R227.2 107.8,31.79 v4(107.56,31.55) 107.31,31.3 R501.2
PCH_RSMRST#: length 10.3
  IN1 w0.06: 110.56,34.65 110.56,34.97 110.69,35.1 110.88,35.1 111.16,35.38 v11(111.16,35.54)
  IN1 w0.071: v2(107.28,34.15) 107.51,33.92 109.83,33.92 110.56,34.65
  GND1 w0.117: v2(107.28,34.15) 107.28,34.12 107.05,33.89 v9(107.03,33.89)
  GND2 w0.117: v9(107.03,33.89) 106.53,34.39 v8(106.53,34.85)
  BOTTOM w0.117: v8(106.53,34.85) R208.2 106.04,35.87 106.03,35.87 R207.2 105.68,36.12 105.5,36.3 104.21,36.3 v4(104.08,36.43)
PCH_SLP_WLAN#: length 50
  IN1 w0.06: 110.93,34.65 111.02,34.75 111.02,35.06 111.33,35.38 111.33,35.42 111.73,35.81 v11(112.12,35.81)
  IN1 w0.071: 110.93,34.65 110.04,33.77 106.52,33.77 105.74,32.99 105.37,32.99 105.2,32.82 105.2,32.29 103.14,30.23 100.5,30.23 100.27,30 100.27,29.09 99.59,28.4 99.49,28.4 v2(98.98,27.9)
  GND1 w0.127: v9(97.78,27.97) 97.86,27.9 v2(98.98,27.9)
  IN3 w0.094: v7(93.72,28.18) 94.12,27.78 96.6,27.78 96.8,27.97 v9(97.78,27.97)
  IN4 w0.071: v8(89.66,47.39) 89.94,47.11 91.27,47.11 92.58,45.8 93.46,45.8 93.88,45.38 93.88,44.99 95.29,43.57 95.29,36.38 94.89,35.97 94.89,35.52 95.37,35.03 95.37,30.08 93.72,28.43 v7(93.72,28.18)
  BOTTOM w0.117: PR74.2 88.69,48.96 89.17,48.48 v4(89.17,48.11) 89.17,47.87 v8(89.66,47.39)
PCH_SPI_CLK: length 94
  IN2 w0.064: v3(110.46,38.65) 110.28,38.83 108.76,38.83 108.07,38.13 107.59,38.13 105.75,39.97 104.68,39.97 104.35,40.29
  IN2 w0.081: v3(45.16,49.84) 48.61,46.39 48.61,42.53 49.45,41.69 50.11,41.69 52.47,39.33 52.47,33.05 51.5,32.08 51.5,29.86 52.1,29.26 55.79,29.26 57.16,30.62 63.74,30.62 64.33,31.21 65.59,31.21 67.48,33.1 70.26,33.1 70.89,32.47 71.75,32.47 73.09,31.13 77.16,31.13 77.75,30.54 82.02,30.54 86.73,35.26 86.73,38.69 88.71,40.66 95.56,40.66 95.73,40.49 96.18,40.49 96.81,41.13 96.81,41.14 97.03,41.35 97.03,41.35 97.09,41.41 99.99,41.41 100.48,40.91 103.73,40.91 104.35,40.29
PCH_SPI_CS0#: length 97.7
  TOP w0.06: R90.2 R326.2 105.33,38.87 v3(105.53,39.07)
  IN2 w0.064: v3(109.16,38.6) 109.03,38.6 108.13,37.71 106.73,37.71 106.14,38.29 106.14,38.82 105.89,39.07 v3(105.53,39.07)
  IN2 w0.081: v3(105.53,39.07) 105.45,39.15 105.45,39.2 105.1,39.56 104.27,39.56 103.5,40.33 101.92,40.33 101.83,40.24 101.83,40.05 101.75,39.96 101.59,39.96 101.51,40.05 101.51,40.24 101.43,40.33 100.2,40.33 100.15,40.28 96.92,40.28 95.99,39.35 95.87,39.35 95.69,39.53 95.57,39.53 95.46,39.41 95.46,39.3 95.64,39.12 95.64,39 95.53,38.89 95.41,38.89 95.23,39.07 95.11,39.07 95,38.95 95,38.84 95.18,38.66 95.18,38.54 94.23,37.59 94.23,36.49 91.45,33.71 88.49,33.71 84.7,29.92 77.58,29.92 76.91,30.59 72.86,30.59 71.64,31.82 66.97,31.82 65.81,30.66 64.56,30.66 63.97,30.07 57.38,30.07 55.99,28.69 51.86,28.69 50.03,30.52 50.03,30.77 50.11,30.85 50.79,30.85 50.87,30.93 50.87,31.1 50.79,31.18 50.11,31.18 50.03,31.26 50.03,31.42 50.11,31.5 50.79,31.5 50.87,31.58 50.87,31.75 50.79,31.83 50.11,31.83 50.03,31.91 50.03,32.07 50.11,32.15 50.79,32.15 50.87,32.23 50.87,32.4 50.79,32.48 50.11,32.48 50.03,32.56 50.03,33.97 49.78,34.22 49.78,35.44 50.47,36.13 50.84,36.13 50.92,36.21 50.92,36.38 50.84,36.46 50.11,36.46 50.03,36.54 50.03,36.7 50.11,36.78 50.84,36.78 50.92,36.86 50.92,37.03 50.84,37.11 50.11,37.11 50.03,37.19 50.03,37.52 50.13,37.62 50.84,37.62 50.94,37.72 50.94,37.83 50.84,37.93 50.13,37.93 50.03,38.03 50.03,38.16 50.11,38.24 50.97,38.24 51.05,38.32 51.05,38.48 50.97,38.57 50.11,38.57 50.03,38.65 50.03,38.81 50.11,38.89 50.97,38.89 51.05,38.97 51.05,39.13 50.97,39.22 50.11,39.22 50.03,39.3 50.03,39.51 47.92,41.61 47.92,42.22 v3(47.57,42.58)
PCH_SPI_IO2: length 93.1
  TOP w0.109: v3(102.37,39.73) 102.1,40.01 R86.2
  IN2 w0.064: v3(110.78,38.31) 110.55,38.31 110.52,38.34 109.29,38.34 108.99,38.03 108.65,38.03 108.2,37.58 106.67,37.58 105.53,38.72 ; 99.39,40.05 100.3,40.05 100.35,40.1 100.83,40.1 101.2,39.73 v3(102.37,39.73)
  IN2 w0.081: v3(102.37,39.73) 102.79,40.15 103.4,40.15 104.75,38.79 105.46,38.79 105.53,38.72 ; v3(46.12,42.53) 46.12,43.8 46.3,43.97 47.79,43.97 47.87,43.89 47.87,43.73 47.79,43.65 46.6,43.65 46.51,43.57 46.51,43.41 46.6,43.32 47.79,43.32 47.87,43.24 47.87,43.08 47.79,43 46.69,43 46.53,42.83 46.53,42.17 47.48,41.22 47.78,41.22 49.82,39.17 49.82,35.9 49.55,35.62 49.55,33.93 49.82,33.66 49.82,30.43 51.78,28.47 56.07,28.47 57.47,29.87 64.06,29.87 64.64,30.45 65.9,30.45 67.05,31.61 71.55,31.61 72.78,30.38 76.82,30.38 77.61,29.59 84.67,29.59 88.58,33.5 91.53,33.5 94.44,36.41 94.44,37.51 96.98,40.05 99.39,40.05
PCH_SPI_IO3: length 95.4
  IN2 w0.064: v3(111.35,38.26) 111.18,38.08 110.59,38.08 110.46,38.21 109.39,38.21 109.06,37.88 108.71,37.88 108.28,37.45 106.61,37.45 105.53,38.54 105.34,38.54
  IN2 w0.081: 105.34,38.54 104.73,38.54 103.35,39.92 102.99,39.92 102.48,39.41 101.23,39.41 100.8,39.84 v3(100.53,39.84) 100.47,39.78 97.01,39.78 94.65,37.42 94.65,36.32 91.62,33.29 89.08,33.29 88.74,32.95 88.74,32.56 88.93,32.36 88.93,32.25 88.81,32.13 88.7,32.13 88.16,32.67 88.05,32.67 87.93,32.56 87.93,32.44 88.27,32.11 88.27,31.99 88.15,31.88 88.04,31.88 87.7,32.21 87.59,32.21 84.7,29.33 77.58,29.33 76.77,30.14 72.73,30.14 71.47,31.4 67.14,31.4 65.99,30.25 64.73,30.25 64.14,29.66 57.55,29.66 56.16,28.27 51.7,28.27 49.61,30.35 49.61,31.35 49.53,31.43 48.82,31.43 48.74,31.51 48.74,31.67 48.82,31.75 49.53,31.75 49.61,31.83 49.61,32 49.53,32.08 48.82,32.08 48.74,32.16 48.74,32.32 48.82,32.4 49.53,32.4 49.61,32.48 49.61,32.65 49.53,32.73 48.82,32.73 48.74,32.81 48.74,32.97 48.82,33.05 49.53,33.05 49.61,33.13 49.61,33.3 49.53,33.38 48.82,33.38 48.74,33.46 48.74,35.21 49.61,36.09 49.61,38.75 46.65,41.71 46.25,41.71 45,42.96 44.6,42.96 v3(44.16,42.53)
PCH_SPI_SI: length 98.5
  TOP w0.109: R77.2 98.47,40.97 98.78,40.67 v3(99.04,40.67)
  IN1 w0.06: v1(108.81,38.95) 108.7,38.95 108.58,38.83 108.48,38.83 108.38,38.72 108.2,38.72 107.83,39.09 106.28,39.09 105.99,39.38 105.63,39.38 v3(105.53,39.48)
  IN2 w0.064: v3(105.53,39.48) 105.17,39.84 104.28,39.84 103.83,40.29
  IN2 w0.081: v3(43.68,49.84) 48.25,45.27 48.25,41.99 49.9,40.34 50.62,40.34 51.45,39.5 51.45,38.13 51.15,37.83 51.15,36.91 52.11,35.95 52.11,33.51 51.16,32.56 51.16,29.68 51.95,28.9 55.91,28.9 57.29,30.28 63.88,30.28 64.47,30.87 65.73,30.87 67.62,32.76 70.12,32.76 70.75,32.13 71.62,32.13 72.95,30.8 76.99,30.8 77.58,30.21 82.32,30.21 82.9,30.8 85.29,30.8 88.41,33.92 91.36,33.92 94.02,36.58 94.02,37.57 93.95,37.65 93.87,37.65 93.8,37.73 93.8,37.9 93.87,37.98 94.2,37.98 94.28,38.06 94.28,38.2 94.2,38.29 93.88,38.29 93.8,38.37 93.8,38.53 93.88,38.62 94.58,38.62 94.66,38.69 94.66,38.84 94.58,38.92 93.95,38.92 93.87,39 93.87,39.17 93.95,39.25 94.99,39.25 95.07,39.33 95.07,39.48 94.99,39.56 93.95,39.56 93.87,39.63 93.87,39.8 93.95,39.87 96.22,39.87 96.83,40.49 98.86,40.49 v3(99.04,40.67) 99.43,41.06 99.86,41.06 100.34,40.58 103.55,40.58 103.83,40.29
PCH_SPI_SO: length 94.7
  TOP w0.109: R87.2 102.49,41.49 v3(102.51,41.51)
  IN2 w0.064: v3(111.02,38.63) 110.63,39.02 108.86,39.02 108.78,39.1
  IN2 w0.081: 108.78,39.1 107.79,40.09 106.19,40.09 105.96,40.32 104.83,40.32 103.81,41.33 102.69,41.33 v3(102.51,41.51) 102.05,41.51 101.85,41.31 100.56,41.31 100.02,41.85 97.06,41.85 96.46,41.26 95.73,41.26 95.47,41 88.57,41 86.4,38.83 86.4,35.4 81.94,30.94 77.87,30.94 77.35,31.47 73.23,31.47 71.89,32.8 71.03,32.8 70.4,33.43 67.34,33.43 65.45,31.54 64.19,31.54 63.61,30.95 57.02,30.95 55.66,29.59 52.25,29.59 51.84,30 51.84,31.76 52.9,32.82 52.9,35.91 52.98,35.99 53.63,35.99 53.71,36.07 53.71,36.24 53.63,36.32 52.98,36.32 52.9,36.4 52.9,36.56 52.98,36.64 53.63,36.64 53.71,36.72 53.71,36.89 53.63,36.97 52.98,36.97 52.9,37.05 52.9,37.21 52.98,37.29 53.63,37.29 53.71,37.37 53.71,37.54 53.63,37.62 52.98,37.62 52.9,37.7 52.9,37.86 52.98,37.94 53.63,37.94 53.71,38.02 53.71,38.19 53.63,38.27 52.98,38.27 52.9,38.35 52.9,38.51 52.98,38.59 53.63,38.59 53.71,38.67 53.71,38.84 53.63,38.92 52.98,38.92 52.9,39 52.9,39.16 52.98,39.24 53.63,39.24 53.71,39.32 53.71,39.49 53.63,39.57 52.98,39.57 52.9,39.65 52.9,40.49 50.95,42.45 49.52,42.45 49.42,42.55 v3(49.02,42.55)
PCH_SUSPWRDNACK: length 4.9
  BOTTOM w0.117: R10944.1 48.08,17.41 47.63,16.96 R352.1 47.42,16.82 v4(47.9,16.34) 48.03,16.21 48.03,15.48 49.04,14.47 49.04,14.26 U17.A12
PCH_TRST#: length 3.5
  GND1 w0.127: v2(123.65,48.85) 123.65,49.44 123.69,49.48 123.69,49.76 v9(123.72,49.78)
  GND2 w0.127: v9(123.72,49.78) 123.62,49.89 v8(123.39,50.11)
  BOTTOM w0.117: R173.1 122.17,49.9 122.68,50.4 123.1,50.4 v8(123.39,50.11)
PCH_VRALERT#: length 4.7
  IN1 w0.06: v2(106.9,36.59) 107.43,36.59 107.77,36.25 109.11,36.25 109.15,36.29 109.15,36.46 109.27,36.57 109.42,36.57 v1(109.55,36.7)
  GND1 w0.127: v2(106.9,36.59) 106.83,36.52 v9(106.45,36.52)
  GND2 w0.127: v9(106.45,36.52) 106.41,36.52 106.16,36.76 v8(106.09,36.76)
  BOTTOM w0.117: v8(106.09,36.76) v4(105.38,36.76)
PCIE_BIFURCATION0: length 8.4
  TOP w0.117: v1(124.81,52.19) 124.81,52.31 126.06,53.55 126.06,54.29 126.87,55.1 T10.1
  IN1 w0.071: v1(124.75,48.54) 124.91,48.69 124.91,49.78 124.65,50.03 124.65,52.03 v1(124.81,52.19)
PCIE_BIFURCATION1: length 6.3
  TOP w0.117: T6.1 127.78,52.97 127.53,52.71 127.53,51.91 127.2,51.58 126.77,51.58 126.16,50.97 125.58,50.97 125.29,50.68 125.29,49.32 125,49.03 U3.C56
PCIE_CLKREQ_WLAN#: length 166.2
  TOP w0.117: v1(101.29,38.59) 100.98,38.9 R94.1
  IN1 w0.06: v1(110.29,38.36) 109.11,38.36 108.87,38.12 108.74,38.12 108.62,38 107.91,38 107.61,38.29
  IN1 w0.071: v4(195.27,39.66) 195.77,39.17 195.77,34.82 195.35,34.4 191.88,34.4 189.15,31.67 189.15,28.55 188.4,27.8 188.4,24.81 189.51,23.7 189.51,15.08 188.52,14.09 188.09,14.09 185.42,11.42 180.68,11.42 179.78,10.52 175.32,10.52 174.27,11.57 165.4,11.57 163.41,9.58 149.47,9.58 148.71,8.82 138.37,8.82 136.75,10.45 106.33,10.45 105.04,11.74 102.27,11.74 100.6,13.41 100.05,13.41 98.88,14.58 98.88,23.5 97.17,25.21 97.17,29.04 98.24,30.11 98.24,33.3 99.1,34.17 99.1,34.81 99.38,35.08 99.38,36.24 100.1,36.95 100.1,37.73 100.95,38.59 v1(101.29,38.59) 101.72,38.59 101.9,38.77 102.84,38.77 102.91,38.7 104.15,38.7 104.38,38.47 105.97,38.47 106.2,38.7 107.21,38.7 107.61,38.29
  BOTTOM w0.117: Q12.3 196.72,39.99 196.47,40.25 R194.2 195.85,40.25 v4(195.27,39.66)
PCIE_RCOMPN: length 3.5
  TOP w0.305: U3.A9 110.19,50.39 110.92,51.12 R35.2
PCIE_RCOMPP: length 3.8
  TOP w0.203: 110.79,50.28 110.51,50.01 U3.B10
  TOP w0.305: R35.1 111.37,50.86 110.79,50.28
PCIE_STATIC: length 9.4
  TOP w0.117: v1(129.66,51.29) 130.85,51.29 T15.1
  IN1 w0.06: 126.57,49.14 126,48.57 126,48.22 125.5,47.72 125.08,47.72 124.78,47.41 123.95,47.41 123.81,47.28 v1(123.74,47.28)
  IN1 w0.071: 126.57,49.14 126.82,49.14 129.12,51.45 129.5,51.45 v1(129.66,51.29)
PD#: length 16.8
  IN2 w0.203: v4(243.83,10.84) 239.2,10.84 v4(237.23,12.81)
  BOTTOM w0.203: R432.2 236.34,13.7 236.21,13.82 D36.2 235.38,12.99 v4(236.19,12.17) ; R432.2 236.88,13.16 v4(237.23,12.81) ; R432.2 236.88,14.08 236.71,14.24 R439.1 C437.1 D35.2 ; U19.47 244.19,10.27 243.83,10.63 v4(243.83,10.84)
PECI_R: length 3.6
  BOTTOM w0.117: R387.1 v4(57.25,14.65) 56.01,13.41 U17.B1
PEG TRAINING: length 6.1
  TOP w0.117: T3.1 125.27,52.09 125.24,52.09 v1(124.89,51.73)
  IN1 w0.06: v1(124.76,48.2) 124.91,48.36 124.91,48.36 125.15,48.6 125.15,48.92 125.13,48.94
  IN1 w0.071: v1(124.89,51.73) 124.89,50.15 125.13,49.91 125.13,48.94
PGA: length 4.1
  GND1 w0.127: v9(71.32,45.49) 71.09,45.72 v2(71.09,45.73)
  GND2 w0.127: v9(71.32,45.49) 71.19,45.36 71.19,44.55 v8(71.19,44.54)
  BOTTOM w0.117: v8(71.19,44.54) 71.19,44.36 71.44,44.11 v4(71.75,44.11) 71.75,43.16 72.16,42.75 PR136.1
PGB: length 3.9
  TOP w0.064: v2(71.78,45.97) PU5.C5
  GND1 w0.127: v2(71.78,45.97) 72.03,45.97 v9(72.15,45.84)
  GND2 w0.127: v9(72.15,45.84) 72.39,45.84 v8(72.57,46.02)
  BOTTOM w0.117: v8(72.57,46.02) v4(72.57,46.57) 72.57,46.87 73.68,47.99 PR94.1
PGC: length 6.5
  TOP w0.117: PR18.1 v1(75.56,49.82)
  IN1 w0.071: v1(71.52,45.73) 72.05,45.73 72.79,46.47 72.92,46.47 73.12,46.67 73.12,46.8 75.56,49.24 v1(75.56,49.82)
PGD: length 4.5
  TOP w0.06: 69.77,48.38 69.8,48.4 v2(69.8,48.61)
  TOP w0.064: 69.77,48.38 69.77,47.57 69.67,47.46 69.29,47.46 69.05,47.23 PU5.H3
  GND1 w0.102: v9(69.92,49.18) 69.92,49.11 69.8,48.99 v2(69.8,48.61)
  GND2 w0.127: v8(69.92,49.62) v9(69.92,49.18)
  BOTTOM w0.117: v4(69.36,49.77) 69.36,49.31 69.46,49.21 PR89.1 69.95,49.6 v8(69.92,49.62)
PGE: length 3.6
  GND1 w0.127: v9(71.57,46.45) 71.54,46.47 71.54,46.78 v2(71.52,46.8)
  GND2 w0.127: v8(71.88,46.3) 71.72,46.3 v9(71.57,46.45)
  BOTTOM w0.117: v4(71.44,45.96) 71.57,45.96 71.88,46.27 v8(71.88,46.3) 71.88,46.6 72.97,47.68 PR93.1
PGF: length 1.6
  GND1 w0.102: v2(69.02,46.73) 68.82,46.93 68.82,47.47 v9(69.04,47.69)
  GND2 w0.127: v9(69.04,47.69) 69.22,47.86 v8(69.41,47.86)
PGG: length 1.9
  GND1 w0.06: v9(69.8,47.59) 70.02,47.37 v2(70.02,47.23)
  GND2 w0.127: v8(70.47,48.11) 69.95,47.59 v9(69.8,47.59)
  BOTTOM w0.117: PR91.1 70.7,48.34 v8(70.47,48.11)
PGVR4: length 3.9
  GND1 w0.102: v9(72.89,46.27) 72.87,46.24 v2(72.03,46.24)
  GND2 w0.127: v9(72.89,46.27) 73.43,46.27 v8(73.48,46.32)
  BOTTOM w0.117: PR95.1 PR104.2 73.92,47.36 v4(73.7,47.15) 73.7,46.44 73.59,46.32 v8(73.48,46.32)
PGVR5: length 3.5
  GND1 w0.102: v9(66.7,46.88) 66.87,46.88 v2(67.02,46.73)
  GND2 w0.127: v9(66.7,46.88) 66.78,46.96 v8(67.08,46.96)
  BOTTOM w0.117: v8(67.08,46.96) 66.87,46.75 PR109.1 67.19,46.6 67.31,46.47 67.31,45.9 v4(67.53,45.68) 67.53,45.52 67.36,45.35 PR117.2
PIRQA#: length 8.6
  TOP w0.117: v1(102.41,36.63) 102.33,36.71 102.15,36.71 102.05,36.81 102.05,36.84 R10970.1 ; R113.1 103.32,36.19 v1(103.5,36.38)
  IN1 w0.06: v1(102.41,36.63) 102.51,36.74 103.14,36.74 v1(103.5,36.38)
  IN1 w0.071: v11(108.79,36.46) 108.75,36.51 107.76,36.51 107.43,36.84 106.63,36.84 106.27,36.47 105.58,36.47 105.24,36.81 104.42,36.81 104.12,36.51 103.63,36.51 v1(103.5,36.38)
PLTRST#: length 228.4
  TOP w0.117: R96.2 198.06,38.65 197.81,38.89 v4(197.5,38.89) 197.5,37.93 197.23,37.66 v4(195.08,37.66)
  IN1 w0.06: 105.76,37.74 107.48,37.74 108.04,37.17 108.51,37.17 108.91,37.58 109.26,37.58 109.32,37.64 109.69,37.64 v1(109.99,37.34)
  IN1 w0.071: v4(195.08,37.66) 195.54,37.2 195.54,34.95 195.29,34.7 191.87,34.7 188.9,31.74 188.9,28.62 188.18,27.89 188.18,24.6 189.29,23.49 189.29,15.17 188.43,14.31 188,14.31 185.33,11.64 180.59,11.64 179.69,10.75 175.41,10.75 174.36,11.79 165.31,11.79 163.32,9.8 149.26,9.8 148.5,9.04 141.33,9.04 139.7,10.67 106.42,10.67 105.13,11.96 102.36,11.96 100.69,13.64 100.14,13.64 99.11,14.67 99.11,23.59 97.39,25.3 97.39,28.95 97.97,29.52 v3(97.99,29.52) 98.46,29.99 98.46,33.13 99.4,34.08 99.4,34.79 99.62,35 99.62,35.67 100.32,36.38 100.32,36.94 100.98,37.6 100.98,37.69 101.22,37.93 102,37.93 102.46,38.39 103.27,38.39 103.57,38.09 104.17,38.09 104.29,38.21 105.29,38.21 105.76,37.74
  IN2 w0.094: v3(97.99,29.52) 97.99,29 97.88,28.88 97.39,28.88 97.1,28.59 96.42,28.59 93.99,26.16 93.99,22.58 93,21.59 93,17.83 88.29,13.11 86.01,13.11 85.52,12.62 80.43,12.62 79.46,13.6 74.26,13.6 73,12.34 67.54,12.34 65.96,10.75 60.32,10.75 59.25,9.68 59.25,8.65 57.19,6.59 53.61,6.59 v4(53.58,6.56)
  BOTTOM w0.076: 53.58,7.56 53.58,7.56 53.63,7.61 53.63,8.01 53.39,8.25 U17.M4
  BOTTOM w0.117: C458.1 54.43,5.06 54.25,5.24 54.25,5.44 53.85,5.84 53.85,6.29 v4(53.58,6.56) 53.58,7.56
